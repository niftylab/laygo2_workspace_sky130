v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {CLK_buf} 1790 -990 0 0 2 2 {}
T {WE<3:0>_buf} 2640 -960 0 0 2 2 {}
T {A<4:0>_buf} 710 -3160 0 0 2 2 {}
T {EN_buf} 1490 -2670 0 0 2 2 {}
T {DEC2x4} 2120 -2660 0 0 2 2 {}
T {INPUT_buf} 3340 -3670 0 0 2 2 {}
T {OUTREG<31:0>} 4060 -1840 0 0 2 2 {}
N 2240 -2390 2260 -2390 {
lab=A3}
N 2240 -2370 2260 -2370 {
lab=A4}
N 2240 -2350 2260 -2350 {
lab=EN_buf}
N 2250 -2430 2260 -2430 {
lab=VDD}
N 2250 -2410 2260 -2410 {
lab=VSS}
N 2950 -3370 2970 -3370 {
lab=#net1}
N 2870 -3410 3030 -3410 {
lab=VDD}
N 2870 -3330 3030 -3330 {
lab=VSS}
N 3110 -3370 3130 -3370 {
lab=Di[31]}
N 2800 -3370 2810 -3370 {
lab=Di<31>}
N 1560 -530 1580 -530 {
lab=#net2}
N 1480 -570 1640 -570 {
lab=VDD}
N 1480 -490 1640 -490 {
lab=VSS}
N 1720 -530 1740 -530 {
lab=CLK_buf}
N 1410 -530 1420 -530 {
lab=CLK}
N 3000 -350 3020 -350 {
lab=#net3}
N 2920 -390 3080 -390 {
lab=VDD}
N 2920 -310 3080 -310 {
lab=VSS}
N 3160 -350 3180 -350 {
lab=WE[3]}
N 2850 -350 2860 -350 {
lab=WE3}
N 3000 -470 3020 -470 {
lab=#net4}
N 2920 -510 3080 -510 {
lab=VDD}
N 2920 -430 3080 -430 {
lab=VSS}
N 3160 -470 3180 -470 {
lab=WE[2]}
N 2850 -470 2860 -470 {
lab=WE2}
N 3000 -600 3020 -600 {
lab=#net5}
N 2920 -640 3080 -640 {
lab=VDD}
N 2920 -560 3080 -560 {
lab=VSS}
N 3160 -600 3180 -600 {
lab=WE[1]}
N 2850 -600 2860 -600 {
lab=WE1}
N 3000 -720 3020 -720 {
lab=#net6}
N 2920 -760 3080 -760 {
lab=VDD}
N 2920 -680 3080 -680 {
lab=VSS}
N 3160 -720 3180 -720 {
lab=WE[0]}
N 2850 -720 2860 -720 {
lab=WE0}
N 2950 -3230 2970 -3230 {
lab=#net7}
N 2870 -3270 3030 -3270 {
lab=VDD}
N 2870 -3190 3030 -3190 {
lab=VSS}
N 3110 -3230 3130 -3230 {
lab=Di[27]}
N 2800 -3230 2810 -3230 {
lab=Di<27>}
N 2950 -3090 2970 -3090 {
lab=#net8}
N 2870 -3130 3030 -3130 {
lab=VDD}
N 2870 -3050 3030 -3050 {
lab=VSS}
N 3110 -3090 3130 -3090 {
lab=Di[23]}
N 2800 -3090 2810 -3090 {
lab=Di<23>}
N 2950 -2950 2970 -2950 {
lab=#net9}
N 2870 -2990 3030 -2990 {
lab=VDD}
N 2870 -2910 3030 -2910 {
lab=VSS}
N 3110 -2950 3130 -2950 {
lab=Di[19]}
N 2800 -2950 2810 -2950 {
lab=Di<19>}
N 2950 -2810 2970 -2810 {
lab=#net10}
N 2870 -2850 3030 -2850 {
lab=VDD}
N 2870 -2770 3030 -2770 {
lab=VSS}
N 3110 -2810 3130 -2810 {
lab=Di[15]}
N 2800 -2810 2810 -2810 {
lab=Di<15>}
N 2950 -2670 2970 -2670 {
lab=#net11}
N 2870 -2710 3030 -2710 {
lab=VDD}
N 2870 -2630 3030 -2630 {
lab=VSS}
N 3110 -2670 3130 -2670 {
lab=Di[11]}
N 2800 -2670 2810 -2670 {
lab=Di<11>}
N 2950 -2530 2970 -2530 {
lab=#net12}
N 2870 -2570 3030 -2570 {
lab=VDD}
N 2870 -2490 3030 -2490 {
lab=VSS}
N 3110 -2530 3130 -2530 {
lab=Di[7]}
N 2800 -2530 2810 -2530 {
lab=Di<7>}
N 2950 -2390 2970 -2390 {
lab=#net13}
N 2870 -2430 3030 -2430 {
lab=VDD}
N 2870 -2350 3030 -2350 {
lab=VSS}
N 3110 -2390 3130 -2390 {
lab=Di[3]}
N 2800 -2390 2810 -2390 {
lab=Di<3>}
N 3390 -3370 3410 -3370 {
lab=#net14}
N 3310 -3410 3470 -3410 {
lab=VDD}
N 3310 -3330 3470 -3330 {
lab=VSS}
N 3550 -3370 3570 -3370 {
lab=Di[30]}
N 3240 -3370 3250 -3370 {
lab=Di<30>}
N 3390 -3230 3410 -3230 {
lab=#net15}
N 3310 -3270 3470 -3270 {
lab=VDD}
N 3310 -3190 3470 -3190 {
lab=VSS}
N 3550 -3230 3570 -3230 {
lab=Di[26]}
N 3240 -3230 3250 -3230 {
lab=Di<26>}
N 3390 -3090 3410 -3090 {
lab=#net16}
N 3310 -3130 3470 -3130 {
lab=VDD}
N 3310 -3050 3470 -3050 {
lab=VSS}
N 3550 -3090 3570 -3090 {
lab=Di[22]}
N 3240 -3090 3250 -3090 {
lab=Di<22>}
N 3390 -2950 3410 -2950 {
lab=#net17}
N 3310 -2990 3470 -2990 {
lab=VDD}
N 3310 -2910 3470 -2910 {
lab=VSS}
N 3550 -2950 3570 -2950 {
lab=Di[18]}
N 3240 -2950 3250 -2950 {
lab=Di<18>}
N 3390 -2810 3410 -2810 {
lab=#net18}
N 3310 -2850 3470 -2850 {
lab=VDD}
N 3310 -2770 3470 -2770 {
lab=VSS}
N 3550 -2810 3570 -2810 {
lab=Di[14]}
N 3240 -2810 3250 -2810 {
lab=Di<14>}
N 3390 -2670 3410 -2670 {
lab=#net19}
N 3310 -2710 3470 -2710 {
lab=VDD}
N 3310 -2630 3470 -2630 {
lab=VSS}
N 3550 -2670 3570 -2670 {
lab=Di[10]}
N 3240 -2670 3250 -2670 {
lab=Di<10>}
N 3390 -2530 3410 -2530 {
lab=#net20}
N 3310 -2570 3470 -2570 {
lab=VDD}
N 3310 -2490 3470 -2490 {
lab=VSS}
N 3550 -2530 3570 -2530 {
lab=Di[6]}
N 3240 -2530 3250 -2530 {
lab=Di<6>}
N 3390 -2390 3410 -2390 {
lab=#net21}
N 3310 -2430 3470 -2430 {
lab=VDD}
N 3310 -2350 3470 -2350 {
lab=VSS}
N 3550 -2390 3570 -2390 {
lab=Di[2]}
N 3240 -2390 3250 -2390 {
lab=Di<2>}
N 3830 -3370 3850 -3370 {
lab=#net22}
N 3750 -3410 3910 -3410 {
lab=VDD}
N 3750 -3330 3910 -3330 {
lab=VSS}
N 3990 -3370 4010 -3370 {
lab=Di[29]}
N 3680 -3370 3690 -3370 {
lab=Di<29>}
N 3830 -3230 3850 -3230 {
lab=#net23}
N 3750 -3270 3910 -3270 {
lab=VDD}
N 3750 -3190 3910 -3190 {
lab=VSS}
N 3990 -3230 4010 -3230 {
lab=Di[25]}
N 3680 -3230 3690 -3230 {
lab=Di<25>}
N 3830 -3090 3850 -3090 {
lab=#net24}
N 3750 -3130 3910 -3130 {
lab=VDD}
N 3750 -3050 3910 -3050 {
lab=VSS}
N 3990 -3090 4010 -3090 {
lab=Di[21]}
N 3680 -3090 3690 -3090 {
lab=Di<21>}
N 3830 -2950 3850 -2950 {
lab=#net25}
N 3750 -2990 3910 -2990 {
lab=VDD}
N 3750 -2910 3910 -2910 {
lab=VSS}
N 3990 -2950 4010 -2950 {
lab=Di[17]}
N 3680 -2950 3690 -2950 {
lab=Di<17>}
N 3830 -2810 3850 -2810 {
lab=#net26}
N 3750 -2850 3910 -2850 {
lab=VDD}
N 3750 -2770 3910 -2770 {
lab=VSS}
N 3990 -2810 4010 -2810 {
lab=Di[13]}
N 3680 -2810 3690 -2810 {
lab=Di<13>}
N 3830 -2670 3850 -2670 {
lab=#net27}
N 3750 -2710 3910 -2710 {
lab=VDD}
N 3750 -2630 3910 -2630 {
lab=VSS}
N 3990 -2670 4010 -2670 {
lab=Di[9]}
N 3680 -2670 3690 -2670 {
lab=Di<9>}
N 3830 -2530 3850 -2530 {
lab=#net28}
N 3750 -2570 3910 -2570 {
lab=VDD}
N 3750 -2490 3910 -2490 {
lab=VSS}
N 3990 -2530 4010 -2530 {
lab=Di[5]}
N 3680 -2530 3690 -2530 {
lab=Di<5>}
N 3830 -2390 3850 -2390 {
lab=#net29}
N 3750 -2430 3910 -2430 {
lab=VDD}
N 3750 -2350 3910 -2350 {
lab=VSS}
N 3990 -2390 4010 -2390 {
lab=Di[1]}
N 3680 -2390 3690 -2390 {
lab=Di<1>}
N 4270 -3370 4290 -3370 {
lab=#net30}
N 4190 -3410 4350 -3410 {
lab=VDD}
N 4190 -3330 4350 -3330 {
lab=VSS}
N 4430 -3370 4450 -3370 {
lab=Di[28]}
N 4120 -3370 4130 -3370 {
lab=Di<28>}
N 4270 -3230 4290 -3230 {
lab=#net31}
N 4190 -3270 4350 -3270 {
lab=VDD}
N 4190 -3190 4350 -3190 {
lab=VSS}
N 4430 -3230 4450 -3230 {
lab=Di[24]}
N 4120 -3230 4130 -3230 {
lab=Di<24>}
N 4270 -3090 4290 -3090 {
lab=#net32}
N 4190 -3130 4350 -3130 {
lab=VDD}
N 4190 -3050 4350 -3050 {
lab=VSS}
N 4430 -3090 4450 -3090 {
lab=Di[20]}
N 4120 -3090 4130 -3090 {
lab=Di<20>}
N 4270 -2950 4290 -2950 {
lab=#net33}
N 4190 -2990 4350 -2990 {
lab=VDD}
N 4190 -2910 4350 -2910 {
lab=VSS}
N 4430 -2950 4450 -2950 {
lab=Di[16]}
N 4120 -2950 4130 -2950 {
lab=Di<16>}
N 4270 -2810 4290 -2810 {
lab=#net34}
N 4190 -2850 4350 -2850 {
lab=VDD}
N 4190 -2770 4350 -2770 {
lab=VSS}
N 4430 -2810 4450 -2810 {
lab=Di[12]}
N 4120 -2810 4130 -2810 {
lab=Di<12>}
N 4270 -2670 4290 -2670 {
lab=#net35}
N 4190 -2710 4350 -2710 {
lab=VDD}
N 4190 -2630 4350 -2630 {
lab=VSS}
N 4430 -2670 4450 -2670 {
lab=Di[8]}
N 4120 -2670 4130 -2670 {
lab=Di<8>}
N 4270 -2530 4290 -2530 {
lab=#net36}
N 4190 -2570 4350 -2570 {
lab=VDD}
N 4190 -2490 4350 -2490 {
lab=VSS}
N 4430 -2530 4450 -2530 {
lab=Di[4]}
N 4120 -2530 4130 -2530 {
lab=Di<4>}
N 4270 -2390 4290 -2390 {
lab=#net37}
N 4190 -2430 4350 -2430 {
lab=VDD}
N 4190 -2350 4350 -2350 {
lab=VSS}
N 4430 -2390 4450 -2390 {
lab=Di[0]}
N 4120 -2390 4130 -2390 {
lab=Di<0>}
N 1970 -530 1990 -530 {
lab=#net38}
N 1890 -570 2050 -570 {
lab=VDD}
N 1890 -490 2050 -490 {
lab=VSS}
N 2130 -530 2150 -530 {
lab=CLK_buf2}
N 1820 -530 1830 -530 {
lab=CLK_buf}
N 2390 -530 2410 -530 {
lab=#net39}
N 2310 -570 2470 -570 {
lab=VDD}
N 2310 -490 2470 -490 {
lab=VSS}
N 2610 -530 2630 -530 {
lab=CLK_outreg0}
N 2240 -530 2250 -530 {
lab=CLK_buf2}
N 2390 -680 2410 -680 {
lab=#net40}
N 2310 -720 2470 -720 {
lab=VDD}
N 2310 -640 2470 -640 {
lab=VSS}
N 2610 -680 2630 -680 {
lab=CLK_RAM}
N 2240 -680 2250 -680 {
lab=CLK_buf2}
N 2390 -390 2410 -390 {
lab=#net41}
N 2310 -430 2470 -430 {
lab=VDD}
N 2310 -350 2470 -350 {
lab=VSS}
N 2610 -390 2630 -390 {
lab=CLK_outreg1}
N 2240 -390 2250 -390 {
lab=CLK_buf2}
N 1030 -2510 1050 -2510 {
lab=#net42}
N 950 -2550 1110 -2550 {
lab=VDD}
N 950 -2470 1110 -2470 {
lab=VSS}
N 1190 -2510 1210 -2510 {
lab=A1}
N 880 -2510 890 -2510 {
lab=A<1>}
N 1030 -2630 1050 -2630 {
lab=#net43}
N 950 -2670 1110 -2670 {
lab=VDD}
N 950 -2590 1110 -2590 {
lab=VSS}
N 1190 -2630 1210 -2630 {
lab=A2}
N 880 -2630 890 -2630 {
lab=A<2>}
N 1030 -2760 1050 -2760 {
lab=#net44}
N 950 -2800 1110 -2800 {
lab=VDD}
N 950 -2720 1110 -2720 {
lab=VSS}
N 1190 -2760 1210 -2760 {
lab=A3}
N 880 -2760 890 -2760 {
lab=A<3>}
N 1030 -2880 1050 -2880 {
lab=#net45}
N 950 -2920 1110 -2920 {
lab=VDD}
N 950 -2840 1110 -2840 {
lab=VSS}
N 1190 -2880 1210 -2880 {
lab=A4}
N 880 -2880 890 -2880 {
lab=A<4>}
N 1030 -2390 1050 -2390 {
lab=#net46}
N 950 -2430 1110 -2430 {
lab=VDD}
N 950 -2350 1110 -2350 {
lab=VSS}
N 1190 -2390 1210 -2390 {
lab=A0}
N 880 -2390 890 -2390 {
lab=A<0>}
N 1670 -2390 1690 -2390 {
lab=#net47}
N 1590 -2430 1750 -2430 {
lab=VDD}
N 1590 -2350 1750 -2350 {
lab=VSS}
N 1830 -2390 1850 -2390 {
lab=EN_buf}
N 1470 -2390 1480 -2390 {
lab=EN}
N 800 -2390 880 -2390 {
lab=A<0>}
N 800 -2510 880 -2510 {
lab=A<1>}
N 800 -2630 880 -2630 {
lab=A<2>}
N 800 -2760 880 -2760 {
lab=A<3>}
N 800 -2880 880 -2880 {
lab=A<4>}
N 1210 -2390 1260 -2390 {
lab=A0}
N 1210 -2510 1260 -2510 {
lab=A1}
N 1210 -2630 1260 -2630 {
lab=A2}
N 1210 -2760 1260 -2760 {
lab=A3}
N 1210 -2880 1260 -2880 {
lab=A4}
N 550 -1970 570 -1970 {
lab=Di[0]}
N 550 -1950 570 -1950 {
lab=Di[1]}
N 550 -1930 570 -1930 {
lab=Di[2]}
N 550 -1910 570 -1910 {
lab=Di[3]}
N 550 -1890 570 -1890 {
lab=Di[4]}
N 550 -1870 570 -1870 {
lab=Di[5]}
N 550 -1850 570 -1850 {
lab=Di[6]}
N 550 -1830 570 -1830 {
lab=Di[7]}
N 550 -1810 570 -1810 {
lab=Di[8]}
N 550 -1790 570 -1790 {
lab=Di[9]}
N 550 -1770 570 -1770 {
lab=Di[10]}
N 550 -1750 570 -1750 {
lab=Di[11]}
N 550 -1730 570 -1730 {
lab=Di[12]}
N 550 -1710 570 -1710 {
lab=Di[13]}
N 550 -1690 570 -1690 {
lab=Di[14]}
N 550 -1670 570 -1670 {
lab=Di[15]}
N 550 -1650 570 -1650 {
lab=Di[16]}
N 550 -1630 570 -1630 {
lab=Di[17]}
N 550 -1610 570 -1610 {
lab=Di[18]}
N 550 -1590 570 -1590 {
lab=Di[19]}
N 550 -1570 570 -1570 {
lab=Di[20]}
N 550 -1550 570 -1550 {
lab=Di[21]}
N 550 -1530 570 -1530 {
lab=Di[22]}
N 550 -1510 570 -1510 {
lab=Di[23]}
N 550 -1490 570 -1490 {
lab=Di[24]}
N 550 -1470 570 -1470 {
lab=Di[25]}
N 550 -1450 570 -1450 {
lab=Di[26]}
N 550 -1430 570 -1430 {
lab=Di[27]}
N 550 -1410 570 -1410 {
lab=Di[28]}
N 550 -1390 570 -1390 {
lab=Di[29]}
N 550 -1370 570 -1370 {
lab=Di[30]}
N 550 -1350 570 -1350 {
lab=Di[31]}
N 870 -1970 890 -1970 {
lab=Do[0]}
N 870 -1950 890 -1950 {
lab=Do[1]}
N 870 -1930 890 -1930 {
lab=Do[2]}
N 870 -1910 890 -1910 {
lab=Do[3]}
N 870 -1890 890 -1890 {
lab=Do[4]}
N 870 -1870 890 -1870 {
lab=Do[5]}
N 870 -1850 890 -1850 {
lab=Do[6]}
N 870 -1830 890 -1830 {
lab=Do[7]}
N 870 -1810 890 -1810 {
lab=Do[8]}
N 870 -1790 890 -1790 {
lab=Do[9]}
N 870 -1770 890 -1770 {
lab=Do[10]}
N 870 -1750 890 -1750 {
lab=Do[11]}
N 870 -1730 890 -1730 {
lab=Do[12]}
N 870 -1710 890 -1710 {
lab=Do[13]}
N 870 -1690 890 -1690 {
lab=Do[14]}
N 870 -1670 890 -1670 {
lab=Do[15]}
N 870 -1650 890 -1650 {
lab=Do[16]}
N 870 -1630 890 -1630 {
lab=Do[17]}
N 870 -1610 890 -1610 {
lab=Do[18]}
N 870 -1590 890 -1590 {
lab=Do[19]}
N 870 -1570 890 -1570 {
lab=Do[20]}
N 870 -1550 890 -1550 {
lab=Do[21]}
N 870 -1530 890 -1530 {
lab=Do[22]}
N 870 -1510 890 -1510 {
lab=Do[23]}
N 870 -1490 890 -1490 {
lab=Do[24]}
N 870 -1470 890 -1470 {
lab=Do[25]}
N 870 -1450 890 -1450 {
lab=Do[26]}
N 870 -1430 890 -1430 {
lab=Do[27]}
N 870 -1410 890 -1410 {
lab=Do[28]}
N 870 -1390 890 -1390 {
lab=Do[29]}
N 870 -1370 890 -1370 {
lab=Do[30]}
N 870 -1350 890 -1350 {
lab=Do[31]}
N 700 -1310 700 -1270 {
lab=A0}
N 720 -1310 720 -1270 {
lab=A1}
N 740 -1310 740 -1270 {
lab=A2}
N 2550 -680 2610 -680 {
lab=CLK_RAM}
N 2550 -530 2610 -530 {
lab=CLK_outreg0}
N 2550 -390 2610 -390 {
lab=CLK_outreg1}
N 640 -2080 640 -2010 {
lab=CLK_RAM}
N 1850 -2390 1880 -2390 {
lab=EN_buf}
N 680 -2030 680 -2010 {
lab=WE[0]}
N 700 -2030 700 -2010 {
lab=WE[1]}
N 720 -2030 720 -2010 {
lab=WE[2]}
N 740 -2030 740 -2010 {
lab=WE[3]}
N 770 -2030 770 -2010 {
lab=VDD}
N 790 -2030 790 -2010 {
lab=VSS}
N 660 -2030 660 -2010 {
lab=Y0}
N 2000 -1950 2020 -1950 {
lab=Di[0]}
N 2000 -1930 2020 -1930 {
lab=Di[1]}
N 2000 -1910 2020 -1910 {
lab=Di[2]}
N 2000 -1890 2020 -1890 {
lab=Di[3]}
N 2000 -1870 2020 -1870 {
lab=Di[4]}
N 2000 -1850 2020 -1850 {
lab=Di[5]}
N 2000 -1830 2020 -1830 {
lab=Di[6]}
N 2000 -1810 2020 -1810 {
lab=Di[7]}
N 2000 -1790 2020 -1790 {
lab=Di[8]}
N 2000 -1770 2020 -1770 {
lab=Di[9]}
N 2000 -1750 2020 -1750 {
lab=Di[10]}
N 2000 -1730 2020 -1730 {
lab=Di[11]}
N 2000 -1710 2020 -1710 {
lab=Di[12]}
N 2000 -1690 2020 -1690 {
lab=Di[13]}
N 2000 -1670 2020 -1670 {
lab=Di[14]}
N 2000 -1650 2020 -1650 {
lab=Di[15]}
N 2000 -1630 2020 -1630 {
lab=Di[16]}
N 2000 -1610 2020 -1610 {
lab=Di[17]}
N 2000 -1590 2020 -1590 {
lab=Di[18]}
N 2000 -1570 2020 -1570 {
lab=Di[19]}
N 2000 -1550 2020 -1550 {
lab=Di[20]}
N 2000 -1530 2020 -1530 {
lab=Di[21]}
N 2000 -1510 2020 -1510 {
lab=Di[22]}
N 2000 -1490 2020 -1490 {
lab=Di[23]}
N 2000 -1470 2020 -1470 {
lab=Di[24]}
N 2000 -1450 2020 -1450 {
lab=Di[25]}
N 2000 -1430 2020 -1430 {
lab=Di[26]}
N 2000 -1410 2020 -1410 {
lab=Di[27]}
N 2000 -1390 2020 -1390 {
lab=Di[28]}
N 2000 -1370 2020 -1370 {
lab=Di[29]}
N 2000 -1350 2020 -1350 {
lab=Di[30]}
N 2000 -1330 2020 -1330 {
lab=Di[31]}
N 2320 -1950 2340 -1950 {
lab=Do[0]}
N 2320 -1930 2340 -1930 {
lab=Do[1]}
N 2320 -1910 2340 -1910 {
lab=Do[2]}
N 2320 -1890 2340 -1890 {
lab=Do[3]}
N 2320 -1870 2340 -1870 {
lab=Do[4]}
N 2320 -1850 2340 -1850 {
lab=Do[5]}
N 2320 -1830 2340 -1830 {
lab=Do[6]}
N 2320 -1810 2340 -1810 {
lab=Do[7]}
N 2320 -1790 2340 -1790 {
lab=Do[8]}
N 2320 -1770 2340 -1770 {
lab=Do[9]}
N 2320 -1750 2340 -1750 {
lab=Do[10]}
N 2320 -1730 2340 -1730 {
lab=Do[11]}
N 2320 -1710 2340 -1710 {
lab=Do[12]}
N 2320 -1690 2340 -1690 {
lab=Do[13]}
N 2320 -1670 2340 -1670 {
lab=Do[14]}
N 2320 -1650 2340 -1650 {
lab=Do[15]}
N 2320 -1630 2340 -1630 {
lab=Do[16]}
N 2320 -1610 2340 -1610 {
lab=Do[17]}
N 2320 -1590 2340 -1590 {
lab=Do[18]}
N 2320 -1570 2340 -1570 {
lab=Do[19]}
N 2320 -1550 2340 -1550 {
lab=Do[20]}
N 2320 -1530 2340 -1530 {
lab=Do[21]}
N 2320 -1510 2340 -1510 {
lab=Do[22]}
N 2320 -1490 2340 -1490 {
lab=Do[23]}
N 2320 -1470 2340 -1470 {
lab=Do[24]}
N 2320 -1450 2340 -1450 {
lab=Do[25]}
N 2320 -1430 2340 -1430 {
lab=Do[26]}
N 2320 -1410 2340 -1410 {
lab=Do[27]}
N 2320 -1390 2340 -1390 {
lab=Do[28]}
N 2320 -1370 2340 -1370 {
lab=Do[29]}
N 2320 -1350 2340 -1350 {
lab=Do[30]}
N 2320 -1330 2340 -1330 {
lab=Do[31]}
N 2150 -1290 2150 -1250 {
lab=A0}
N 2170 -1290 2170 -1250 {
lab=A1}
N 2190 -1290 2190 -1250 {
lab=A2}
N 2090 -2060 2090 -1990 {
lab=CLK_RAM}
N 2130 -2010 2130 -1990 {
lab=WE[0]}
N 2150 -2010 2150 -1990 {
lab=WE[1]}
N 2170 -2010 2170 -1990 {
lab=WE[2]}
N 2190 -2010 2190 -1990 {
lab=WE[3]}
N 2220 -2010 2220 -1990 {
lab=VDD}
N 2240 -2010 2240 -1990 {
lab=VSS}
N 2110 -2010 2110 -1990 {
lab=Y2}
N 2770 -1960 2790 -1960 {
lab=Di[0]}
N 2770 -1940 2790 -1940 {
lab=Di[1]}
N 2770 -1920 2790 -1920 {
lab=Di[2]}
N 2770 -1900 2790 -1900 {
lab=Di[3]}
N 2770 -1880 2790 -1880 {
lab=Di[4]}
N 2770 -1860 2790 -1860 {
lab=Di[5]}
N 2770 -1840 2790 -1840 {
lab=Di[6]}
N 2770 -1820 2790 -1820 {
lab=Di[7]}
N 2770 -1800 2790 -1800 {
lab=Di[8]}
N 2770 -1780 2790 -1780 {
lab=Di[9]}
N 2770 -1760 2790 -1760 {
lab=Di[10]}
N 2770 -1740 2790 -1740 {
lab=Di[11]}
N 2770 -1720 2790 -1720 {
lab=Di[12]}
N 2770 -1700 2790 -1700 {
lab=Di[13]}
N 2770 -1680 2790 -1680 {
lab=Di[14]}
N 2770 -1660 2790 -1660 {
lab=Di[15]}
N 2770 -1640 2790 -1640 {
lab=Di[16]}
N 2770 -1620 2790 -1620 {
lab=Di[17]}
N 2770 -1600 2790 -1600 {
lab=Di[18]}
N 2770 -1580 2790 -1580 {
lab=Di[19]}
N 2770 -1560 2790 -1560 {
lab=Di[20]}
N 2770 -1540 2790 -1540 {
lab=Di[21]}
N 2770 -1520 2790 -1520 {
lab=Di[22]}
N 2770 -1500 2790 -1500 {
lab=Di[23]}
N 2770 -1480 2790 -1480 {
lab=Di[24]}
N 2770 -1460 2790 -1460 {
lab=Di[25]}
N 2770 -1440 2790 -1440 {
lab=Di[26]}
N 2770 -1420 2790 -1420 {
lab=Di[27]}
N 2770 -1400 2790 -1400 {
lab=Di[28]}
N 2770 -1380 2790 -1380 {
lab=Di[29]}
N 2770 -1360 2790 -1360 {
lab=Di[30]}
N 2770 -1340 2790 -1340 {
lab=Di[31]}
N 3090 -1960 3110 -1960 {
lab=Do[0]}
N 3090 -1940 3110 -1940 {
lab=Do[1]}
N 3090 -1920 3110 -1920 {
lab=Do[2]}
N 3090 -1900 3110 -1900 {
lab=Do[3]}
N 3090 -1880 3110 -1880 {
lab=Do[4]}
N 3090 -1860 3110 -1860 {
lab=Do[5]}
N 3090 -1840 3110 -1840 {
lab=Do[6]}
N 3090 -1820 3110 -1820 {
lab=Do[7]}
N 3090 -1800 3110 -1800 {
lab=Do[8]}
N 3090 -1780 3110 -1780 {
lab=Do[9]}
N 3090 -1760 3110 -1760 {
lab=Do[10]}
N 3090 -1740 3110 -1740 {
lab=Do[11]}
N 3090 -1720 3110 -1720 {
lab=Do[12]}
N 3090 -1700 3110 -1700 {
lab=Do[13]}
N 3090 -1680 3110 -1680 {
lab=Do[14]}
N 3090 -1660 3110 -1660 {
lab=Do[15]}
N 3090 -1640 3110 -1640 {
lab=Do[16]}
N 3090 -1620 3110 -1620 {
lab=Do[17]}
N 3090 -1600 3110 -1600 {
lab=Do[18]}
N 3090 -1580 3110 -1580 {
lab=Do[19]}
N 3090 -1560 3110 -1560 {
lab=Do[20]}
N 3090 -1540 3110 -1540 {
lab=Do[21]}
N 3090 -1520 3110 -1520 {
lab=Do[22]}
N 3090 -1500 3110 -1500 {
lab=Do[23]}
N 3090 -1480 3110 -1480 {
lab=Do[24]}
N 3090 -1460 3110 -1460 {
lab=Do[25]}
N 3090 -1440 3110 -1440 {
lab=Do[26]}
N 3090 -1420 3110 -1420 {
lab=Do[27]}
N 3090 -1400 3110 -1400 {
lab=Do[28]}
N 3090 -1380 3110 -1380 {
lab=Do[29]}
N 3090 -1360 3110 -1360 {
lab=Do[30]}
N 3090 -1340 3110 -1340 {
lab=Do[31]}
N 2920 -1300 2920 -1260 {
lab=A0}
N 2940 -1300 2940 -1260 {
lab=A1}
N 2960 -1300 2960 -1260 {
lab=A2}
N 2860 -2070 2860 -2000 {
lab=CLK_RAM}
N 2900 -2020 2900 -2000 {
lab=WE[0]}
N 2920 -2020 2920 -2000 {
lab=WE[1]}
N 2940 -2020 2940 -2000 {
lab=WE[2]}
N 2960 -2020 2960 -2000 {
lab=WE[3]}
N 2990 -2020 2990 -2000 {
lab=VDD}
N 3010 -2020 3010 -2000 {
lab=VSS}
N 2880 -2020 2880 -2000 {
lab=Y3}
N 2420 -2420 2440 -2420 {
lab=Y0}
N 2440 -2420 2470 -2420 {
lab=Y0}
N 2420 -2400 2440 -2400 {
lab=Y1}
N 2440 -2400 2470 -2400 {
lab=Y1}
N 2420 -2380 2440 -2380 {
lab=Y2}
N 2440 -2380 2470 -2380 {
lab=Y2}
N 2420 -2360 2440 -2360 {
lab=Y3}
N 2440 -2360 2470 -2360 {
lab=Y3}
N 3790 -1140 3800 -1140 {
lab=Do[8]}
N 3760 -1140 3790 -1140 {
lab=Do[8]}
N 3890 -1080 3890 -1060 {
lab=VSS}
N 3860 -1060 3890 -1060 {
lab=VSS}
N 3890 -1200 3890 -1180 {
lab=VDD}
N 3860 -1200 3890 -1200 {
lab=VDD}
N 3790 -1120 3800 -1120 {
lab=CLK_outreg0}
N 3760 -1120 3790 -1120 {
lab=CLK_outreg0}
N 3990 -1130 4000 -1130 {
lab=Do<8>}
N 3960 -1130 3990 -1130 {
lab=Do<8>}
N 4530 -1140 4540 -1140 {
lab=Do[10]}
N 4500 -1140 4530 -1140 {
lab=Do[10]}
N 4630 -1080 4630 -1060 {
lab=VSS}
N 4600 -1060 4630 -1060 {
lab=VSS}
N 4630 -1200 4630 -1180 {
lab=VDD}
N 4600 -1200 4630 -1200 {
lab=VDD}
N 4530 -1120 4540 -1120 {
lab=CLK_outreg0}
N 4500 -1120 4530 -1120 {
lab=CLK_outreg0}
N 4730 -1130 4740 -1130 {
lab=Do<10>}
N 4700 -1130 4730 -1130 {
lab=Do<10>}
N 3790 -950 3800 -950 {
lab=Do[12]}
N 3760 -950 3790 -950 {
lab=Do[12]}
N 3890 -890 3890 -870 {
lab=VSS}
N 3860 -870 3890 -870 {
lab=VSS}
N 3890 -1010 3890 -990 {
lab=VDD}
N 3860 -1010 3890 -1010 {
lab=VDD}
N 3790 -930 3800 -930 {
lab=CLK_outreg0}
N 3760 -930 3790 -930 {
lab=CLK_outreg0}
N 3990 -940 4000 -940 {
lab=Do<12>}
N 3960 -940 3990 -940 {
lab=Do<12>}
N 4530 -950 4540 -950 {
lab=Do[14]}
N 4500 -950 4530 -950 {
lab=Do[14]}
N 4630 -890 4630 -870 {
lab=VSS}
N 4600 -870 4630 -870 {
lab=VSS}
N 4630 -1010 4630 -990 {
lab=VDD}
N 4600 -1010 4630 -1010 {
lab=VDD}
N 4530 -930 4540 -930 {
lab=CLK_outreg0}
N 4500 -930 4530 -930 {
lab=CLK_outreg0}
N 4730 -940 4740 -940 {
lab=Do<14>}
N 4700 -940 4730 -940 {
lab=Do<14>}
N 3790 -760 3800 -760 {
lab=Do[16]}
N 3760 -760 3790 -760 {
lab=Do[16]}
N 3890 -700 3890 -680 {
lab=VSS}
N 3860 -680 3890 -680 {
lab=VSS}
N 3890 -820 3890 -800 {
lab=VDD}
N 3860 -820 3890 -820 {
lab=VDD}
N 3790 -740 3800 -740 {
lab=CLK_outreg0}
N 3760 -740 3790 -740 {
lab=CLK_outreg0}
N 3990 -750 4000 -750 {
lab=Do<16>}
N 3960 -750 3990 -750 {
lab=Do<16>}
N 4530 -760 4540 -760 {
lab=Do[18]}
N 4500 -760 4530 -760 {
lab=Do[18]}
N 4630 -700 4630 -680 {
lab=VSS}
N 4600 -680 4630 -680 {
lab=VSS}
N 4630 -820 4630 -800 {
lab=VDD}
N 4600 -820 4630 -820 {
lab=VDD}
N 4530 -740 4540 -740 {
lab=CLK_outreg0}
N 4500 -740 4530 -740 {
lab=CLK_outreg0}
N 4730 -750 4740 -750 {
lab=Do<18>}
N 4700 -750 4730 -750 {
lab=Do<18>}
N 3790 -570 3800 -570 {
lab=Do[20]}
N 3760 -570 3790 -570 {
lab=Do[20]}
N 3890 -510 3890 -490 {
lab=VSS}
N 3860 -490 3890 -490 {
lab=VSS}
N 3890 -630 3890 -610 {
lab=VDD}
N 3860 -630 3890 -630 {
lab=VDD}
N 3790 -550 3800 -550 {
lab=CLK_outreg0}
N 3760 -550 3790 -550 {
lab=CLK_outreg0}
N 3990 -560 4000 -560 {
lab=Do<20>}
N 3960 -560 3990 -560 {
lab=Do<20>}
N 4530 -570 4540 -570 {
lab=Do[22]}
N 4500 -570 4530 -570 {
lab=Do[22]}
N 4630 -510 4630 -490 {
lab=VSS}
N 4600 -490 4630 -490 {
lab=VSS}
N 4630 -630 4630 -610 {
lab=VDD}
N 4600 -630 4630 -630 {
lab=VDD}
N 4530 -550 4540 -550 {
lab=CLK_outreg0}
N 4500 -550 4530 -550 {
lab=CLK_outreg0}
N 4730 -560 4740 -560 {
lab=Do<22>}
N 4700 -560 4730 -560 {
lab=Do<22>}
N 3790 -380 3800 -380 {
lab=Do[24]}
N 3760 -380 3790 -380 {
lab=Do[24]}
N 3890 -320 3890 -300 {
lab=VSS}
N 3860 -300 3890 -300 {
lab=VSS}
N 3890 -440 3890 -420 {
lab=VDD}
N 3860 -440 3890 -440 {
lab=VDD}
N 3790 -360 3800 -360 {
lab=CLK_outreg0}
N 3760 -360 3790 -360 {
lab=CLK_outreg0}
N 3990 -370 4000 -370 {
lab=Do<24>}
N 3960 -370 3990 -370 {
lab=Do<24>}
N 4530 -380 4540 -380 {
lab=Do[26]}
N 4500 -380 4530 -380 {
lab=Do[26]}
N 4630 -320 4630 -300 {
lab=VSS}
N 4600 -300 4630 -300 {
lab=VSS}
N 4630 -440 4630 -420 {
lab=VDD}
N 4600 -440 4630 -440 {
lab=VDD}
N 4530 -360 4540 -360 {
lab=CLK_outreg0}
N 4500 -360 4530 -360 {
lab=CLK_outreg0}
N 4730 -370 4740 -370 {
lab=Do<26>}
N 4700 -370 4730 -370 {
lab=Do<26>}
N 3790 -190 3800 -190 {
lab=Do[28]}
N 3760 -190 3790 -190 {
lab=Do[28]}
N 3890 -130 3890 -110 {
lab=VSS}
N 3860 -110 3890 -110 {
lab=VSS}
N 3890 -250 3890 -230 {
lab=VDD}
N 3860 -250 3890 -250 {
lab=VDD}
N 3790 -170 3800 -170 {
lab=CLK_outreg0}
N 3760 -170 3790 -170 {
lab=CLK_outreg0}
N 3990 -180 4000 -180 {
lab=Do<28>}
N 3960 -180 3990 -180 {
lab=Do<28>}
N 4530 -190 4540 -190 {
lab=Do[30]}
N 4500 -190 4530 -190 {
lab=Do[30]}
N 4630 -130 4630 -110 {
lab=VSS}
N 4600 -110 4630 -110 {
lab=VSS}
N 4630 -250 4630 -230 {
lab=VDD}
N 4600 -250 4630 -250 {
lab=VDD}
N 4530 -170 4540 -170 {
lab=CLK_outreg0}
N 4500 -170 4530 -170 {
lab=CLK_outreg0}
N 4730 -180 4740 -180 {
lab=Do<30>}
N 4700 -180 4730 -180 {
lab=Do<30>}
N 3790 -1520 3800 -1520 {
lab=Do[0]}
N 3760 -1520 3790 -1520 {
lab=Do[0]}
N 3890 -1460 3890 -1440 {
lab=VSS}
N 3860 -1440 3890 -1440 {
lab=VSS}
N 3890 -1580 3890 -1560 {
lab=VDD}
N 3860 -1580 3890 -1580 {
lab=VDD}
N 3790 -1500 3800 -1500 {
lab=CLK_outreg0}
N 3760 -1500 3790 -1500 {
lab=CLK_outreg0}
N 3990 -1510 4000 -1510 {
lab=Do<0>}
N 3960 -1510 3990 -1510 {
lab=Do<0>}
N 4530 -1520 4540 -1520 {
lab=Do[2]}
N 4500 -1520 4530 -1520 {
lab=Do[2]}
N 4630 -1460 4630 -1440 {
lab=VSS}
N 4600 -1440 4630 -1440 {
lab=VSS}
N 4630 -1580 4630 -1560 {
lab=VDD}
N 4600 -1580 4630 -1580 {
lab=VDD}
N 4530 -1500 4540 -1500 {
lab=CLK_outreg0}
N 4500 -1500 4530 -1500 {
lab=CLK_outreg0}
N 4730 -1510 4740 -1510 {
lab=Do<2>}
N 4700 -1510 4730 -1510 {
lab=Do<2>}
N 3790 -1330 3800 -1330 {
lab=Do[4]}
N 3760 -1330 3790 -1330 {
lab=Do[4]}
N 3890 -1270 3890 -1250 {
lab=VSS}
N 3860 -1250 3890 -1250 {
lab=VSS}
N 3890 -1390 3890 -1370 {
lab=VDD}
N 3860 -1390 3890 -1390 {
lab=VDD}
N 3790 -1310 3800 -1310 {
lab=CLK_outreg0}
N 3760 -1310 3790 -1310 {
lab=CLK_outreg0}
N 3990 -1320 4000 -1320 {
lab=Do<4>}
N 3960 -1320 3990 -1320 {
lab=Do<4>}
N 4530 -1330 4540 -1330 {
lab=Do[6]}
N 4500 -1330 4530 -1330 {
lab=Do[6]}
N 4630 -1270 4630 -1250 {
lab=VSS}
N 4600 -1250 4630 -1250 {
lab=VSS}
N 4630 -1390 4630 -1370 {
lab=VDD}
N 4600 -1390 4630 -1390 {
lab=VDD}
N 4530 -1310 4540 -1310 {
lab=CLK_outreg0}
N 4500 -1310 4530 -1310 {
lab=CLK_outreg0}
N 4730 -1320 4740 -1320 {
lab=Do<6>}
N 4700 -1320 4730 -1320 {
lab=Do<6>}
N 4910 -1520 4920 -1520 {
lab=Do[3]}
N 4880 -1520 4910 -1520 {
lab=Do[3]}
N 5010 -1460 5010 -1440 {
lab=VSS}
N 4980 -1440 5010 -1440 {
lab=VSS}
N 5010 -1580 5010 -1560 {
lab=VDD}
N 4980 -1580 5010 -1580 {
lab=VDD}
N 4910 -1500 4920 -1500 {
lab=CLK_outreg1}
N 4880 -1500 4910 -1500 {
lab=CLK_outreg1}
N 5110 -1510 5120 -1510 {
lab=Do<3>}
N 5080 -1510 5110 -1510 {
lab=Do<3>}
N 4160 -1520 4170 -1520 {
lab=Do[1]}
N 4130 -1520 4160 -1520 {
lab=Do[1]}
N 4260 -1460 4260 -1440 {
lab=VSS}
N 4230 -1440 4260 -1440 {
lab=VSS}
N 4260 -1580 4260 -1560 {
lab=VDD}
N 4230 -1580 4260 -1580 {
lab=VDD}
N 4160 -1500 4170 -1500 {
lab=CLK_outreg1}
N 4130 -1500 4160 -1500 {
lab=CLK_outreg1}
N 4360 -1510 4370 -1510 {
lab=Do<1>}
N 4330 -1510 4360 -1510 {
lab=Do<1>}
N 4910 -1330 4920 -1330 {
lab=Do[7]}
N 4880 -1330 4910 -1330 {
lab=Do[7]}
N 5010 -1270 5010 -1250 {
lab=VSS}
N 4980 -1250 5010 -1250 {
lab=VSS}
N 5010 -1390 5010 -1370 {
lab=VDD}
N 4980 -1390 5010 -1390 {
lab=VDD}
N 4910 -1310 4920 -1310 {
lab=CLK_outreg1}
N 4880 -1310 4910 -1310 {
lab=CLK_outreg1}
N 5110 -1320 5120 -1320 {
lab=Do<7>}
N 5080 -1320 5110 -1320 {
lab=Do<7>}
N 4160 -1330 4170 -1330 {
lab=Do[5]}
N 4130 -1330 4160 -1330 {
lab=Do[5]}
N 4260 -1270 4260 -1250 {
lab=VSS}
N 4230 -1250 4260 -1250 {
lab=VSS}
N 4260 -1390 4260 -1370 {
lab=VDD}
N 4230 -1390 4260 -1390 {
lab=VDD}
N 4160 -1310 4170 -1310 {
lab=CLK_outreg1}
N 4130 -1310 4160 -1310 {
lab=CLK_outreg1}
N 4360 -1320 4370 -1320 {
lab=Do<5>}
N 4330 -1320 4360 -1320 {
lab=Do<5>}
N 4910 -1140 4920 -1140 {
lab=Do[11]}
N 4880 -1140 4910 -1140 {
lab=Do[11]}
N 5010 -1080 5010 -1060 {
lab=VSS}
N 4980 -1060 5010 -1060 {
lab=VSS}
N 5010 -1200 5010 -1180 {
lab=VDD}
N 4980 -1200 5010 -1200 {
lab=VDD}
N 4910 -1120 4920 -1120 {
lab=CLK_outreg1}
N 4880 -1120 4910 -1120 {
lab=CLK_outreg1}
N 5110 -1130 5120 -1130 {
lab=Do<11>}
N 5080 -1130 5110 -1130 {
lab=Do<11>}
N 4160 -1140 4170 -1140 {
lab=Do[9]}
N 4130 -1140 4160 -1140 {
lab=Do[9]}
N 4260 -1080 4260 -1060 {
lab=VSS}
N 4230 -1060 4260 -1060 {
lab=VSS}
N 4260 -1200 4260 -1180 {
lab=VDD}
N 4230 -1200 4260 -1200 {
lab=VDD}
N 4160 -1120 4170 -1120 {
lab=CLK_outreg1}
N 4130 -1120 4160 -1120 {
lab=CLK_outreg1}
N 4360 -1130 4370 -1130 {
lab=Do<9>}
N 4330 -1130 4360 -1130 {
lab=Do<9>}
N 4910 -950 4920 -950 {
lab=Do[15]}
N 4880 -950 4910 -950 {
lab=Do[15]}
N 5010 -890 5010 -870 {
lab=VSS}
N 4980 -870 5010 -870 {
lab=VSS}
N 5010 -1010 5010 -990 {
lab=VDD}
N 4980 -1010 5010 -1010 {
lab=VDD}
N 4910 -930 4920 -930 {
lab=CLK_outreg1}
N 4880 -930 4910 -930 {
lab=CLK_outreg1}
N 5110 -940 5120 -940 {
lab=Do<15>}
N 5080 -940 5110 -940 {
lab=Do<15>}
N 4160 -950 4170 -950 {
lab=Do[13]}
N 4130 -950 4160 -950 {
lab=Do[13]}
N 4260 -890 4260 -870 {
lab=VSS}
N 4230 -870 4260 -870 {
lab=VSS}
N 4260 -1010 4260 -990 {
lab=VDD}
N 4230 -1010 4260 -1010 {
lab=VDD}
N 4160 -930 4170 -930 {
lab=CLK_outreg1}
N 4130 -930 4160 -930 {
lab=CLK_outreg1}
N 4360 -940 4370 -940 {
lab=Do<13>}
N 4330 -940 4360 -940 {
lab=Do<13>}
N 4910 -760 4920 -760 {
lab=Do[19]}
N 4880 -760 4910 -760 {
lab=Do[19]}
N 5010 -700 5010 -680 {
lab=VSS}
N 4980 -680 5010 -680 {
lab=VSS}
N 5010 -820 5010 -800 {
lab=VDD}
N 4980 -820 5010 -820 {
lab=VDD}
N 4910 -740 4920 -740 {
lab=CLK_outreg1}
N 4880 -740 4910 -740 {
lab=CLK_outreg1}
N 5110 -750 5120 -750 {
lab=Do<19>}
N 5080 -750 5110 -750 {
lab=Do<19>}
N 4160 -760 4170 -760 {
lab=Do[17]}
N 4130 -760 4160 -760 {
lab=Do[17]}
N 4260 -700 4260 -680 {
lab=VSS}
N 4230 -680 4260 -680 {
lab=VSS}
N 4260 -820 4260 -800 {
lab=VDD}
N 4230 -820 4260 -820 {
lab=VDD}
N 4160 -740 4170 -740 {
lab=CLK_outreg1}
N 4130 -740 4160 -740 {
lab=CLK_outreg1}
N 4360 -750 4370 -750 {
lab=Do<17>}
N 4330 -750 4360 -750 {
lab=Do<17>}
N 4910 -570 4920 -570 {
lab=Do[23]}
N 4880 -570 4910 -570 {
lab=Do[23]}
N 5010 -510 5010 -490 {
lab=VSS}
N 4980 -490 5010 -490 {
lab=VSS}
N 5010 -630 5010 -610 {
lab=VDD}
N 4980 -630 5010 -630 {
lab=VDD}
N 4910 -550 4920 -550 {
lab=CLK_outreg1}
N 4880 -550 4910 -550 {
lab=CLK_outreg1}
N 5110 -560 5120 -560 {
lab=Do<23>}
N 5080 -560 5110 -560 {
lab=Do<23>}
N 4160 -570 4170 -570 {
lab=Do[21]}
N 4130 -570 4160 -570 {
lab=Do[21]}
N 4260 -510 4260 -490 {
lab=VSS}
N 4230 -490 4260 -490 {
lab=VSS}
N 4260 -630 4260 -610 {
lab=VDD}
N 4230 -630 4260 -630 {
lab=VDD}
N 4160 -550 4170 -550 {
lab=CLK_outreg1}
N 4130 -550 4160 -550 {
lab=CLK_outreg1}
N 4360 -560 4370 -560 {
lab=Do<21>}
N 4330 -560 4360 -560 {
lab=Do<21>}
N 4910 -380 4920 -380 {
lab=Do[27]}
N 4880 -380 4910 -380 {
lab=Do[27]}
N 5010 -320 5010 -300 {
lab=VSS}
N 4980 -300 5010 -300 {
lab=VSS}
N 5010 -440 5010 -420 {
lab=VDD}
N 4980 -440 5010 -440 {
lab=VDD}
N 4910 -360 4920 -360 {
lab=CLK_outreg1}
N 4880 -360 4910 -360 {
lab=CLK_outreg1}
N 5110 -370 5120 -370 {
lab=Do<27>}
N 5080 -370 5110 -370 {
lab=Do<27>}
N 4160 -380 4170 -380 {
lab=Do[25]}
N 4130 -380 4160 -380 {
lab=Do[25]}
N 4260 -320 4260 -300 {
lab=VSS}
N 4230 -300 4260 -300 {
lab=VSS}
N 4260 -440 4260 -420 {
lab=VDD}
N 4230 -440 4260 -440 {
lab=VDD}
N 4160 -360 4170 -360 {
lab=CLK_outreg1}
N 4130 -360 4160 -360 {
lab=CLK_outreg1}
N 4360 -370 4370 -370 {
lab=Do<25>}
N 4330 -370 4360 -370 {
lab=Do<25>}
N 4910 -190 4920 -190 {
lab=Do[31]}
N 4880 -190 4910 -190 {
lab=Do[31]}
N 5010 -130 5010 -110 {
lab=VSS}
N 4980 -110 5010 -110 {
lab=VSS}
N 5010 -250 5010 -230 {
lab=VDD}
N 4980 -250 5010 -250 {
lab=VDD}
N 4910 -170 4920 -170 {
lab=CLK_outreg1}
N 4880 -170 4910 -170 {
lab=CLK_outreg1}
N 5110 -180 5120 -180 {
lab=Do<31>}
N 5080 -180 5110 -180 {
lab=Do<31>}
N 4160 -190 4170 -190 {
lab=Do[29]}
N 4130 -190 4160 -190 {
lab=Do[29]}
N 4260 -130 4260 -110 {
lab=VSS}
N 4230 -110 4260 -110 {
lab=VSS}
N 4260 -250 4260 -230 {
lab=VDD}
N 4230 -250 4260 -250 {
lab=VDD}
N 4160 -170 4170 -170 {
lab=CLK_outreg1}
N 4130 -170 4160 -170 {
lab=CLK_outreg1}
N 4360 -180 4370 -180 {
lab=Do<29>}
N 4330 -180 4360 -180 {
lab=Do<29>}
N 1480 -2390 1530 -2390 {
lab=EN}
N 1280 -1950 1300 -1950 {
lab=Di[0]}
N 1280 -1930 1300 -1930 {
lab=Di[1]}
N 1280 -1910 1300 -1910 {
lab=Di[2]}
N 1280 -1890 1300 -1890 {
lab=Di[3]}
N 1280 -1870 1300 -1870 {
lab=Di[4]}
N 1280 -1850 1300 -1850 {
lab=Di[5]}
N 1280 -1830 1300 -1830 {
lab=Di[6]}
N 1280 -1810 1300 -1810 {
lab=Di[7]}
N 1280 -1790 1300 -1790 {
lab=Di[8]}
N 1280 -1770 1300 -1770 {
lab=Di[9]}
N 1280 -1750 1300 -1750 {
lab=Di[10]}
N 1280 -1730 1300 -1730 {
lab=Di[11]}
N 1280 -1710 1300 -1710 {
lab=Di[12]}
N 1280 -1690 1300 -1690 {
lab=Di[13]}
N 1280 -1670 1300 -1670 {
lab=Di[14]}
N 1280 -1650 1300 -1650 {
lab=Di[15]}
N 1280 -1630 1300 -1630 {
lab=Di[16]}
N 1280 -1610 1300 -1610 {
lab=Di[17]}
N 1280 -1590 1300 -1590 {
lab=Di[18]}
N 1280 -1570 1300 -1570 {
lab=Di[19]}
N 1280 -1550 1300 -1550 {
lab=Di[20]}
N 1280 -1530 1300 -1530 {
lab=Di[21]}
N 1280 -1510 1300 -1510 {
lab=Di[22]}
N 1280 -1490 1300 -1490 {
lab=Di[23]}
N 1280 -1470 1300 -1470 {
lab=Di[24]}
N 1280 -1450 1300 -1450 {
lab=Di[25]}
N 1280 -1430 1300 -1430 {
lab=Di[26]}
N 1280 -1410 1300 -1410 {
lab=Di[27]}
N 1280 -1390 1300 -1390 {
lab=Di[28]}
N 1280 -1370 1300 -1370 {
lab=Di[29]}
N 1280 -1350 1300 -1350 {
lab=Di[30]}
N 1280 -1330 1300 -1330 {
lab=Di[31]}
N 1600 -1950 1620 -1950 {
lab=Do[0]}
N 1600 -1930 1620 -1930 {
lab=Do[1]}
N 1600 -1910 1620 -1910 {
lab=Do[2]}
N 1600 -1890 1620 -1890 {
lab=Do[3]}
N 1600 -1870 1620 -1870 {
lab=Do[4]}
N 1600 -1850 1620 -1850 {
lab=Do[5]}
N 1600 -1830 1620 -1830 {
lab=Do[6]}
N 1600 -1810 1620 -1810 {
lab=Do[7]}
N 1600 -1790 1620 -1790 {
lab=Do[8]}
N 1600 -1770 1620 -1770 {
lab=Do[9]}
N 1600 -1750 1620 -1750 {
lab=Do[10]}
N 1600 -1730 1620 -1730 {
lab=Do[11]}
N 1600 -1710 1620 -1710 {
lab=Do[12]}
N 1600 -1690 1620 -1690 {
lab=Do[13]}
N 1600 -1670 1620 -1670 {
lab=Do[14]}
N 1600 -1650 1620 -1650 {
lab=Do[15]}
N 1600 -1630 1620 -1630 {
lab=Do[16]}
N 1600 -1610 1620 -1610 {
lab=Do[17]}
N 1600 -1590 1620 -1590 {
lab=Do[18]}
N 1600 -1570 1620 -1570 {
lab=Do[19]}
N 1600 -1550 1620 -1550 {
lab=Do[20]}
N 1600 -1530 1620 -1530 {
lab=Do[21]}
N 1600 -1510 1620 -1510 {
lab=Do[22]}
N 1600 -1490 1620 -1490 {
lab=Do[23]}
N 1600 -1470 1620 -1470 {
lab=Do[24]}
N 1600 -1450 1620 -1450 {
lab=Do[25]}
N 1600 -1430 1620 -1430 {
lab=Do[26]}
N 1600 -1410 1620 -1410 {
lab=Do[27]}
N 1600 -1390 1620 -1390 {
lab=Do[28]}
N 1600 -1370 1620 -1370 {
lab=Do[29]}
N 1600 -1350 1620 -1350 {
lab=Do[30]}
N 1600 -1330 1620 -1330 {
lab=Do[31]}
N 1430 -1290 1430 -1250 {
lab=A0}
N 1450 -1290 1450 -1250 {
lab=A1}
N 1470 -1290 1470 -1250 {
lab=A2}
N 1370 -2060 1370 -1990 {
lab=CLK_RAM}
N 1410 -2010 1410 -1990 {
lab=WE[0]}
N 1430 -2010 1430 -1990 {
lab=WE[1]}
N 1450 -2010 1450 -1990 {
lab=WE[2]}
N 1470 -2010 1470 -1990 {
lab=WE[3]}
N 1500 -2010 1500 -1990 {
lab=VDD}
N 1520 -2010 1520 -1990 {
lab=VSS}
N 1390 -2010 1390 -1990 {
lab=Y2}
C {xschem_lib/sylee21/dec_2to4.sym} 2340 -2390 0 0 {name=x1 NF=2}
C {ipin.sym} 800 -2630 0 0 {name=p4 lab=A<2>}
C {ipin.sym} 800 -2510 0 0 {name=p5 lab=A<1>}
C {ipin.sym} 800 -2390 0 0 {name=p6 lab=A<0>}
C {lab_wire.sym} 2250 -2430 0 0 {name=l2273 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2250 -2410 0 0 {name=l2274 sig_type=std_logic lab=VSS}
C {xschem_lib/inv.sym} 2810 -3330 0 0 {name=X_inv1 NF=24}
C {xschem_lib/inv.sym} 2970 -3330 0 0 {name=X_inv2 NF=24}
C {lab_wire.sym} 2950 -3410 0 0 {name=l2283 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 -3330 0 0 {name=l2284 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2800 -3370 0 0 {name=l2317 sig_type=std_logic lab=Di<31>}
C {lab_wire.sym} 3130 -3370 0 0 {name=l2318 sig_type=std_logic lab=Di[31]}
C {xschem_lib/inv.sym} 1420 -490 0 0 {name=X_inv65 NF=14}
C {xschem_lib/inv.sym} 1580 -490 0 0 {name=X_inv66 NF=14}
C {lab_wire.sym} 1560 -570 0 0 {name=l2489 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1560 -490 0 0 {name=l2490 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1410 -530 0 0 {name=l2491 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1740 -530 0 0 {name=l2492 sig_type=std_logic lab=CLK_buf}
C {xschem_lib/inv.sym} 2860 -310 0 0 {name=X_inv67 NF=36}
C {xschem_lib/inv.sym} 3020 -310 0 0 {name=X_inv68 NF=36}
C {lab_wire.sym} 3000 -390 0 0 {name=l2493 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -310 0 0 {name=l2494 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2850 -350 0 0 {name=l2495 sig_type=std_logic lab=WE3}
C {lab_wire.sym} 3180 -350 0 0 {name=l2496 sig_type=std_logic lab=WE[3]}
C {xschem_lib/inv.sym} 2860 -430 0 0 {name=X_inv69 NF=36}
C {xschem_lib/inv.sym} 3020 -430 0 0 {name=X_inv70 NF=36}
C {lab_wire.sym} 3000 -510 0 0 {name=l2497 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -430 0 0 {name=l2498 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2850 -470 0 0 {name=l2499 sig_type=std_logic lab=WE2}
C {lab_wire.sym} 3180 -470 0 0 {name=l2500 sig_type=std_logic lab=WE[2]}
C {xschem_lib/inv.sym} 2860 -560 0 0 {name=X_inv71 NF=36}
C {xschem_lib/inv.sym} 3020 -560 0 0 {name=X_inv72 NF=36}
C {lab_wire.sym} 3000 -640 0 0 {name=l2501 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -560 0 0 {name=l2502 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2850 -600 0 0 {name=l2503 sig_type=std_logic lab=WE1}
C {lab_wire.sym} 3180 -600 0 0 {name=l2504 sig_type=std_logic lab=WE[1]}
C {xschem_lib/inv.sym} 2860 -680 0 0 {name=X_inv73 NF=36}
C {xschem_lib/inv.sym} 3020 -680 0 0 {name=X_inv74 NF=36}
C {lab_wire.sym} 3000 -760 0 0 {name=l2505 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -680 0 0 {name=l2506 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2850 -720 0 0 {name=l2507 sig_type=std_logic lab=WE0}
C {lab_wire.sym} 3180 -720 0 0 {name=l2508 sig_type=std_logic lab=WE[0]}
C {devices/ipin.sym} 560 -920 0 0 {name=p7 lab=Di<0>}
C {devices/opin.sym} 480 -610 0 0 {name=p39 lab=Do<0>}
C {devices/ipin.sym} 650 -920 0 0 {name=p8 lab=Di<1>}
C {devices/opin.sym} 570 -610 0 0 {name=p40 lab=Do<1>}
C {devices/ipin.sym} 740 -920 0 0 {name=p9 lab=Di<2>}
C {devices/opin.sym} 660 -610 0 0 {name=p1 lab=Do<2>}
C {devices/ipin.sym} 830 -920 0 0 {name=p10 lab=Di<3>}
C {devices/opin.sym} 750 -610 0 0 {name=p2 lab=Do<3>}
C {devices/ipin.sym} 560 -890 0 0 {name=p11 lab=Di<4>}
C {devices/opin.sym} 480 -580 0 0 {name=p43 lab=Do<4>}
C {devices/ipin.sym} 650 -890 0 0 {name=p12 lab=Di<5>}
C {devices/opin.sym} 570 -580 0 0 {name=p3 lab=Do<5>}
C {devices/ipin.sym} 740 -890 0 0 {name=p13 lab=Di<6>}
C {devices/opin.sym} 660 -580 0 0 {name=p41 lab=Do<6>}
C {devices/ipin.sym} 830 -890 0 0 {name=p14 lab=Di<7>}
C {devices/opin.sym} 750 -580 0 0 {name=p42 lab=Do<7>}
C {devices/ipin.sym} 560 -860 0 0 {name=p15 lab=Di<8>}
C {devices/opin.sym} 480 -550 0 0 {name=p47 lab=Do<8>}
C {devices/ipin.sym} 650 -860 0 0 {name=p16 lab=Di<9>}
C {devices/opin.sym} 570 -550 0 0 {name=p44 lab=Do<9>}
C {devices/ipin.sym} 740 -860 0 0 {name=p17 lab=Di<10>}
C {devices/opin.sym} 660 -550 0 0 {name=p45 lab=Do<10>}
C {devices/ipin.sym} 830 -860 0 0 {name=p18 lab=Di<11>}
C {devices/opin.sym} 750 -550 0 0 {name=p46 lab=Do<11>}
C {devices/ipin.sym} 560 -830 0 0 {name=p19 lab=Di<12>}
C {devices/opin.sym} 480 -520 0 0 {name=p51 lab=Do<12>}
C {devices/ipin.sym} 650 -830 0 0 {name=p20 lab=Di<13>}
C {devices/opin.sym} 570 -520 0 0 {name=p48 lab=Do<13>}
C {devices/ipin.sym} 740 -830 0 0 {name=p21 lab=Di<14>}
C {devices/opin.sym} 660 -520 0 0 {name=p49 lab=Do<14>}
C {devices/ipin.sym} 830 -830 0 0 {name=p22 lab=Di<15>}
C {devices/opin.sym} 750 -520 0 0 {name=p50 lab=Do<15>}
C {devices/ipin.sym} 560 -800 0 0 {name=p23 lab=Di<16>}
C {devices/opin.sym} 480 -490 0 0 {name=p55 lab=Do<16>}
C {devices/ipin.sym} 650 -800 0 0 {name=p24 lab=Di<17>}
C {devices/opin.sym} 570 -490 0 0 {name=p52 lab=Do<17>}
C {devices/ipin.sym} 740 -800 0 0 {name=p25 lab=Di<18>}
C {devices/opin.sym} 660 -490 0 0 {name=p53 lab=Do<18>}
C {devices/ipin.sym} 830 -800 0 0 {name=p26 lab=Di<19>}
C {devices/opin.sym} 750 -490 0 0 {name=p54 lab=Do<19>}
C {devices/ipin.sym} 560 -770 0 0 {name=p27 lab=Di<20>}
C {devices/opin.sym} 480 -460 0 0 {name=p59 lab=Do<20>}
C {devices/ipin.sym} 650 -770 0 0 {name=p28 lab=Di<21>}
C {devices/opin.sym} 570 -460 0 0 {name=p56 lab=Do<21>}
C {devices/ipin.sym} 740 -770 0 0 {name=p29 lab=Di<22>}
C {devices/opin.sym} 660 -460 0 0 {name=p57 lab=Do<22>}
C {devices/ipin.sym} 830 -770 0 0 {name=p30 lab=Di<23>}
C {devices/opin.sym} 750 -460 0 0 {name=p58 lab=Do<23>}
C {devices/ipin.sym} 560 -740 0 0 {name=p31 lab=Di<24>}
C {devices/opin.sym} 480 -430 0 0 {name=p63 lab=Do<24>}
C {devices/ipin.sym} 650 -740 0 0 {name=p32 lab=Di<25>}
C {devices/opin.sym} 570 -430 0 0 {name=p60 lab=Do<25>}
C {devices/ipin.sym} 740 -740 0 0 {name=p33 lab=Di<26>}
C {devices/opin.sym} 660 -430 0 0 {name=p61 lab=Do<26>}
C {devices/ipin.sym} 830 -740 0 0 {name=p34 lab=Di<27>}
C {devices/opin.sym} 750 -430 0 0 {name=p62 lab=Do<27>}
C {devices/ipin.sym} 560 -710 0 0 {name=p35 lab=Di<28>}
C {devices/opin.sym} 480 -400 0 0 {name=p67 lab=Do<28>}
C {devices/ipin.sym} 650 -710 0 0 {name=p36 lab=Di<29>}
C {devices/opin.sym} 570 -400 0 0 {name=p64 lab=Do<29>}
C {devices/ipin.sym} 740 -710 0 0 {name=p37 lab=Di<30>}
C {devices/opin.sym} 660 -400 0 0 {name=p65 lab=Do<30>}
C {devices/ipin.sym} 830 -710 0 0 {name=p38 lab=Di<31>}
C {devices/opin.sym} 750 -400 0 0 {name=p66 lab=Do<31>}
C {iopin.sym} 960 -920 0 0 {name=p71 lab=VDD}
C {iopin.sym} 960 -890 0 0 {name=p72 lab=VSS}
C {ipin.sym} 1010 -840 0 0 {name=p73 lab=WE0}
C {ipin.sym} 1010 -810 0 0 {name=p74 lab=WE1}
C {ipin.sym} 1010 -780 0 0 {name=p75 lab=WE2}
C {ipin.sym} 1010 -750 0 0 {name=p76 lab=WE3}
C {ipin.sym} 1010 -710 0 0 {name=p77 lab=CLK}
C {xschem_lib/sylee21/RAM8bit.sym} 720 -1700 0 0 {name=RAM8}
C {xschem_lib/inv.sym} 2810 -3190 0 0 {name=X_inv3 NF=24}
C {xschem_lib/inv.sym} 2970 -3190 0 0 {name=X_inv4 NF=24}
C {lab_wire.sym} 2950 -3270 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 -3190 0 0 {name=l2 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2800 -3230 0 0 {name=l3 sig_type=std_logic lab=Di<27>}
C {lab_wire.sym} 3130 -3230 0 0 {name=l4 sig_type=std_logic lab=Di[27]}
C {xschem_lib/inv.sym} 2810 -3050 0 0 {name=X_inv5 NF=24}
C {xschem_lib/inv.sym} 2970 -3050 0 0 {name=X_inv6 NF=24}
C {lab_wire.sym} 2950 -3130 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 -3050 0 0 {name=l6 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2800 -3090 0 0 {name=l7 sig_type=std_logic lab=Di<23>}
C {lab_wire.sym} 3130 -3090 0 0 {name=l8 sig_type=std_logic lab=Di[23]}
C {xschem_lib/inv.sym} 2810 -2910 0 0 {name=X_inv7 NF=24}
C {xschem_lib/inv.sym} 2970 -2910 0 0 {name=X_inv8 NF=24}
C {lab_wire.sym} 2950 -2990 0 0 {name=l9 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 -2910 0 0 {name=l10 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2800 -2950 0 0 {name=l11 sig_type=std_logic lab=Di<19>}
C {lab_wire.sym} 3130 -2950 0 0 {name=l12 sig_type=std_logic lab=Di[19]}
C {xschem_lib/inv.sym} 2810 -2770 0 0 {name=X_inv9 NF=24}
C {xschem_lib/inv.sym} 2970 -2770 0 0 {name=X_inv10 NF=24}
C {lab_wire.sym} 2950 -2850 0 0 {name=l13 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 -2770 0 0 {name=l14 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2800 -2810 0 0 {name=l15 sig_type=std_logic lab=Di<15>}
C {lab_wire.sym} 3130 -2810 0 0 {name=l16 sig_type=std_logic lab=Di[15]}
C {xschem_lib/inv.sym} 2810 -2630 0 0 {name=X_inv11 NF=24}
C {xschem_lib/inv.sym} 2970 -2630 0 0 {name=X_inv12 NF=24}
C {lab_wire.sym} 2950 -2710 0 0 {name=l17 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 -2630 0 0 {name=l18 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2800 -2670 0 0 {name=l19 sig_type=std_logic lab=Di<11>}
C {lab_wire.sym} 3130 -2670 0 0 {name=l20 sig_type=std_logic lab=Di[11]}
C {xschem_lib/inv.sym} 2810 -2490 0 0 {name=X_inv13 NF=24}
C {xschem_lib/inv.sym} 2970 -2490 0 0 {name=X_inv14 NF=24}
C {lab_wire.sym} 2950 -2570 0 0 {name=l21 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 -2490 0 0 {name=l22 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2800 -2530 0 0 {name=l23 sig_type=std_logic lab=Di<7>}
C {lab_wire.sym} 3130 -2530 0 0 {name=l24 sig_type=std_logic lab=Di[7]}
C {xschem_lib/inv.sym} 2810 -2350 0 0 {name=X_inv15 NF=24}
C {xschem_lib/inv.sym} 2970 -2350 0 0 {name=X_inv16 NF=24}
C {lab_wire.sym} 2950 -2430 0 0 {name=l25 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 -2350 0 0 {name=l26 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2800 -2390 0 0 {name=l27 sig_type=std_logic lab=Di<3>}
C {lab_wire.sym} 3130 -2390 0 0 {name=l28 sig_type=std_logic lab=Di[3]}
C {xschem_lib/inv.sym} 3250 -3330 0 0 {name=X_inv17 NF=24}
C {xschem_lib/inv.sym} 3410 -3330 0 0 {name=X_inv18 NF=24}
C {lab_wire.sym} 3390 -3410 0 0 {name=l29 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3390 -3330 0 0 {name=l30 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3240 -3370 0 0 {name=l31 sig_type=std_logic lab=Di<30>}
C {lab_wire.sym} 3570 -3370 0 0 {name=l32 sig_type=std_logic lab=Di[30]}
C {xschem_lib/inv.sym} 3250 -3190 0 0 {name=X_inv19 NF=24}
C {xschem_lib/inv.sym} 3410 -3190 0 0 {name=X_inv20 NF=24}
C {lab_wire.sym} 3390 -3270 0 0 {name=l33 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3390 -3190 0 0 {name=l34 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3240 -3230 0 0 {name=l35 sig_type=std_logic lab=Di<26>}
C {lab_wire.sym} 3570 -3230 0 0 {name=l36 sig_type=std_logic lab=Di[26]}
C {xschem_lib/inv.sym} 3250 -3050 0 0 {name=X_inv21 NF=24}
C {xschem_lib/inv.sym} 3410 -3050 0 0 {name=X_inv22 NF=24}
C {lab_wire.sym} 3390 -3130 0 0 {name=l37 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3390 -3050 0 0 {name=l38 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3240 -3090 0 0 {name=l39 sig_type=std_logic lab=Di<22>}
C {lab_wire.sym} 3570 -3090 0 0 {name=l40 sig_type=std_logic lab=Di[22]}
C {xschem_lib/inv.sym} 3250 -2910 0 0 {name=X_inv23 NF=24}
C {xschem_lib/inv.sym} 3410 -2910 0 0 {name=X_inv24 NF=24}
C {lab_wire.sym} 3390 -2990 0 0 {name=l41 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3390 -2910 0 0 {name=l42 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3240 -2950 0 0 {name=l43 sig_type=std_logic lab=Di<18>}
C {lab_wire.sym} 3570 -2950 0 0 {name=l44 sig_type=std_logic lab=Di[18]}
C {xschem_lib/inv.sym} 3250 -2770 0 0 {name=X_inv25 NF=24}
C {xschem_lib/inv.sym} 3410 -2770 0 0 {name=X_inv26 NF=24}
C {lab_wire.sym} 3390 -2850 0 0 {name=l45 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3390 -2770 0 0 {name=l46 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3240 -2810 0 0 {name=l47 sig_type=std_logic lab=Di<14>}
C {lab_wire.sym} 3570 -2810 0 0 {name=l48 sig_type=std_logic lab=Di[14]}
C {xschem_lib/inv.sym} 3250 -2630 0 0 {name=X_inv27 NF=24}
C {xschem_lib/inv.sym} 3410 -2630 0 0 {name=X_inv28 NF=24}
C {lab_wire.sym} 3390 -2710 0 0 {name=l49 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3390 -2630 0 0 {name=l50 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3240 -2670 0 0 {name=l51 sig_type=std_logic lab=Di<10>}
C {lab_wire.sym} 3570 -2670 0 0 {name=l52 sig_type=std_logic lab=Di[10]}
C {xschem_lib/inv.sym} 3250 -2490 0 0 {name=X_inv29 NF=24}
C {xschem_lib/inv.sym} 3410 -2490 0 0 {name=X_inv30 NF=24}
C {lab_wire.sym} 3390 -2570 0 0 {name=l53 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3390 -2490 0 0 {name=l54 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3240 -2530 0 0 {name=l55 sig_type=std_logic lab=Di<6>}
C {lab_wire.sym} 3570 -2530 0 0 {name=l56 sig_type=std_logic lab=Di[6]}
C {xschem_lib/inv.sym} 3250 -2350 0 0 {name=X_inv31 NF=24}
C {xschem_lib/inv.sym} 3410 -2350 0 0 {name=X_inv32 NF=24}
C {lab_wire.sym} 3390 -2430 0 0 {name=l57 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3390 -2350 0 0 {name=l58 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3240 -2390 0 0 {name=l59 sig_type=std_logic lab=Di<2>}
C {lab_wire.sym} 3570 -2390 0 0 {name=l60 sig_type=std_logic lab=Di[2]}
C {xschem_lib/inv.sym} 3690 -3330 0 0 {name=X_inv33 NF=24}
C {xschem_lib/inv.sym} 3850 -3330 0 0 {name=X_inv34 NF=24}
C {lab_wire.sym} 3830 -3410 0 0 {name=l61 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3830 -3330 0 0 {name=l62 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3680 -3370 0 0 {name=l63 sig_type=std_logic lab=Di<29>}
C {lab_wire.sym} 4010 -3370 0 0 {name=l64 sig_type=std_logic lab=Di[29]}
C {xschem_lib/inv.sym} 3690 -3190 0 0 {name=X_inv35 NF=24}
C {xschem_lib/inv.sym} 3850 -3190 0 0 {name=X_inv36 NF=24}
C {lab_wire.sym} 3830 -3270 0 0 {name=l65 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3830 -3190 0 0 {name=l66 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3680 -3230 0 0 {name=l67 sig_type=std_logic lab=Di<25>}
C {lab_wire.sym} 4010 -3230 0 0 {name=l68 sig_type=std_logic lab=Di[25]}
C {xschem_lib/inv.sym} 3690 -3050 0 0 {name=X_inv37 NF=24}
C {xschem_lib/inv.sym} 3850 -3050 0 0 {name=X_inv38 NF=24}
C {lab_wire.sym} 3830 -3130 0 0 {name=l69 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3830 -3050 0 0 {name=l70 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3680 -3090 0 0 {name=l71 sig_type=std_logic lab=Di<21>}
C {lab_wire.sym} 4010 -3090 0 0 {name=l72 sig_type=std_logic lab=Di[21]}
C {xschem_lib/inv.sym} 3690 -2910 0 0 {name=X_inv39 NF=24}
C {xschem_lib/inv.sym} 3850 -2910 0 0 {name=X_inv40 NF=24}
C {lab_wire.sym} 3830 -2990 0 0 {name=l73 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3830 -2910 0 0 {name=l74 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3680 -2950 0 0 {name=l75 sig_type=std_logic lab=Di<17>}
C {lab_wire.sym} 4010 -2950 0 0 {name=l76 sig_type=std_logic lab=Di[17]}
C {xschem_lib/inv.sym} 3690 -2770 0 0 {name=X_inv41 NF=24}
C {xschem_lib/inv.sym} 3850 -2770 0 0 {name=X_inv42 NF=24}
C {lab_wire.sym} 3830 -2850 0 0 {name=l77 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3830 -2770 0 0 {name=l78 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3680 -2810 0 0 {name=l79 sig_type=std_logic lab=Di<13>}
C {lab_wire.sym} 4010 -2810 0 0 {name=l80 sig_type=std_logic lab=Di[13]}
C {xschem_lib/inv.sym} 3690 -2630 0 0 {name=X_inv43 NF=24}
C {xschem_lib/inv.sym} 3850 -2630 0 0 {name=X_inv44 NF=24}
C {lab_wire.sym} 3830 -2710 0 0 {name=l81 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3830 -2630 0 0 {name=l82 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3680 -2670 0 0 {name=l83 sig_type=std_logic lab=Di<9>}
C {lab_wire.sym} 4010 -2670 0 0 {name=l84 sig_type=std_logic lab=Di[9]}
C {xschem_lib/inv.sym} 3690 -2490 0 0 {name=X_inv45 NF=24}
C {xschem_lib/inv.sym} 3850 -2490 0 0 {name=X_inv46 NF=24}
C {lab_wire.sym} 3830 -2570 0 0 {name=l85 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3830 -2490 0 0 {name=l86 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3680 -2530 0 0 {name=l87 sig_type=std_logic lab=Di<5>}
C {lab_wire.sym} 4010 -2530 0 0 {name=l88 sig_type=std_logic lab=Di[5]}
C {xschem_lib/inv.sym} 3690 -2350 0 0 {name=X_inv47 NF=24}
C {xschem_lib/inv.sym} 3850 -2350 0 0 {name=X_inv48 NF=24}
C {lab_wire.sym} 3830 -2430 0 0 {name=l89 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3830 -2350 0 0 {name=l90 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3680 -2390 0 0 {name=l91 sig_type=std_logic lab=Di<1>}
C {lab_wire.sym} 4010 -2390 0 0 {name=l92 sig_type=std_logic lab=Di[1]}
C {xschem_lib/inv.sym} 4130 -3330 0 0 {name=X_inv49 NF=24}
C {xschem_lib/inv.sym} 4290 -3330 0 0 {name=X_inv50 NF=24}
C {lab_wire.sym} 4270 -3410 0 0 {name=l93 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4270 -3330 0 0 {name=l94 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4120 -3370 0 0 {name=l95 sig_type=std_logic lab=Di<28>}
C {lab_wire.sym} 4450 -3370 0 0 {name=l96 sig_type=std_logic lab=Di[28]}
C {xschem_lib/inv.sym} 4130 -3190 0 0 {name=X_inv51 NF=24}
C {xschem_lib/inv.sym} 4290 -3190 0 0 {name=X_inv52 NF=24}
C {lab_wire.sym} 4270 -3270 0 0 {name=l97 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4270 -3190 0 0 {name=l98 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4120 -3230 0 0 {name=l99 sig_type=std_logic lab=Di<24>}
C {lab_wire.sym} 4450 -3230 0 0 {name=l100 sig_type=std_logic lab=Di[24]}
C {xschem_lib/inv.sym} 4130 -3050 0 0 {name=X_inv53 NF=24}
C {xschem_lib/inv.sym} 4290 -3050 0 0 {name=X_inv54 NF=24}
C {lab_wire.sym} 4270 -3130 0 0 {name=l101 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4270 -3050 0 0 {name=l102 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4120 -3090 0 0 {name=l103 sig_type=std_logic lab=Di<20>}
C {lab_wire.sym} 4450 -3090 0 0 {name=l104 sig_type=std_logic lab=Di[20]}
C {xschem_lib/inv.sym} 4130 -2910 0 0 {name=X_inv55 NF=24}
C {xschem_lib/inv.sym} 4290 -2910 0 0 {name=X_inv56 NF=24}
C {lab_wire.sym} 4270 -2990 0 0 {name=l105 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4270 -2910 0 0 {name=l106 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4120 -2950 0 0 {name=l107 sig_type=std_logic lab=Di<16>}
C {lab_wire.sym} 4450 -2950 0 0 {name=l108 sig_type=std_logic lab=Di[16]}
C {xschem_lib/inv.sym} 4130 -2770 0 0 {name=X_inv57 NF=24}
C {xschem_lib/inv.sym} 4290 -2770 0 0 {name=X_inv58 NF=24}
C {lab_wire.sym} 4270 -2850 0 0 {name=l109 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4270 -2770 0 0 {name=l110 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4120 -2810 0 0 {name=l111 sig_type=std_logic lab=Di<12>}
C {lab_wire.sym} 4450 -2810 0 0 {name=l112 sig_type=std_logic lab=Di[12]}
C {xschem_lib/inv.sym} 4130 -2630 0 0 {name=X_inv59 NF=24}
C {xschem_lib/inv.sym} 4290 -2630 0 0 {name=X_inv60 NF=24}
C {lab_wire.sym} 4270 -2710 0 0 {name=l113 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4270 -2630 0 0 {name=l114 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4120 -2670 0 0 {name=l115 sig_type=std_logic lab=Di<8>}
C {lab_wire.sym} 4450 -2670 0 0 {name=l116 sig_type=std_logic lab=Di[8]}
C {xschem_lib/inv.sym} 4130 -2490 0 0 {name=X_inv61 NF=24}
C {xschem_lib/inv.sym} 4290 -2490 0 0 {name=X_inv62 NF=24}
C {lab_wire.sym} 4270 -2570 0 0 {name=l117 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4270 -2490 0 0 {name=l118 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4120 -2530 0 0 {name=l119 sig_type=std_logic lab=Di<4>}
C {lab_wire.sym} 4450 -2530 0 0 {name=l120 sig_type=std_logic lab=Di[4]}
C {xschem_lib/inv.sym} 4130 -2350 0 0 {name=X_inv63 NF=24}
C {xschem_lib/inv.sym} 4290 -2350 0 0 {name=X_inv64 NF=24}
C {lab_wire.sym} 4270 -2430 0 0 {name=l121 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4270 -2350 0 0 {name=l122 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4120 -2390 0 0 {name=l123 sig_type=std_logic lab=Di<0>}
C {lab_wire.sym} 4450 -2390 0 0 {name=l124 sig_type=std_logic lab=Di[0]}
C {xschem_lib/inv.sym} 1830 -490 0 0 {name=X_inv75 NF=36}
C {xschem_lib/inv.sym} 1990 -490 0 0 {name=X_inv76 NF=36}
C {lab_wire.sym} 1970 -570 0 0 {name=l125 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1970 -490 0 0 {name=l126 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1820 -530 0 0 {name=l127 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2150 -530 0 0 {name=l128 sig_type=std_logic lab=CLK_buf2}
C {xschem_lib/inv.sym} 2250 -490 0 0 {name=X_inv77 NF=36}
C {xschem_lib/inv.sym} 2410 -490 0 0 {name=X_inv78 NF=36}
C {lab_wire.sym} 2390 -570 0 0 {name=l129 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2390 -490 0 0 {name=l130 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2240 -530 0 0 {name=l131 sig_type=std_logic lab=CLK_buf2}
C {lab_wire.sym} 2630 -530 0 0 {name=l132 sig_type=std_logic lab=CLK_outreg0}
C {xschem_lib/inv.sym} 2250 -640 0 0 {name=X_inv79 NF=36}
C {xschem_lib/inv.sym} 2410 -640 0 0 {name=X_inv80 NF=36}
C {lab_wire.sym} 2390 -720 0 0 {name=l133 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2390 -640 0 0 {name=l134 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2240 -680 0 0 {name=l135 sig_type=std_logic lab=CLK_buf2}
C {lab_wire.sym} 2630 -680 0 0 {name=l136 sig_type=std_logic lab=CLK_RAM}
C {xschem_lib/inv.sym} 2250 -350 0 0 {name=X_inv81 NF=36}
C {xschem_lib/inv.sym} 2410 -350 0 0 {name=X_inv82 NF=36}
C {lab_wire.sym} 2390 -430 0 0 {name=l137 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2390 -350 0 0 {name=l138 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2240 -390 0 0 {name=l139 sig_type=std_logic lab=CLK_buf2}
C {lab_wire.sym} 2630 -390 0 0 {name=l140 sig_type=std_logic lab=CLK_outreg1}
C {xschem_lib/inv.sym} 890 -2470 0 0 {name=X_inv83 NF=24}
C {xschem_lib/inv.sym} 1050 -2470 0 0 {name=X_inv84 NF=24}
C {lab_wire.sym} 1030 -2550 0 0 {name=l141 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1030 -2470 0 0 {name=l142 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1260 -2510 0 0 {name=l144 sig_type=std_logic lab=A1}
C {xschem_lib/inv.sym} 890 -2590 0 0 {name=X_inv85 NF=24}
C {xschem_lib/inv.sym} 1050 -2590 0 0 {name=X_inv86 NF=24}
C {lab_wire.sym} 1030 -2670 0 0 {name=l145 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1030 -2590 0 0 {name=l146 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1260 -2630 0 0 {name=l148 sig_type=std_logic lab=A2}
C {xschem_lib/inv.sym} 890 -2720 0 0 {name=X_inv87 NF=24}
C {xschem_lib/inv.sym} 1050 -2720 0 0 {name=X_inv88 NF=24}
C {lab_wire.sym} 1030 -2800 0 0 {name=l149 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1030 -2720 0 0 {name=l150 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1260 -2760 0 0 {name=l152 sig_type=std_logic lab=A3}
C {xschem_lib/inv.sym} 890 -2840 0 0 {name=X_inv89 NF=24}
C {xschem_lib/inv.sym} 1050 -2840 0 0 {name=X_inv90 NF=24}
C {lab_wire.sym} 1030 -2920 0 0 {name=l153 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1030 -2840 0 0 {name=l154 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1260 -2880 0 0 {name=l156 sig_type=std_logic lab=A4}
C {xschem_lib/inv.sym} 890 -2350 0 0 {name=X_inv91 NF=24}
C {xschem_lib/inv.sym} 1050 -2350 0 0 {name=X_inv92 NF=24}
C {lab_wire.sym} 1030 -2430 0 0 {name=l157 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1030 -2350 0 0 {name=l158 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1260 -2390 0 0 {name=l160 sig_type=std_logic lab=A0}
C {xschem_lib/inv.sym} 1530 -2350 0 0 {name=X_inv93 NF=24}
C {xschem_lib/inv.sym} 1690 -2350 0 0 {name=X_inv94 NF=24}
C {lab_wire.sym} 1670 -2430 0 0 {name=l161 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1670 -2350 0 0 {name=l162 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1470 -2390 0 0 {name=l163 sig_type=std_logic lab=EN}
C {lab_wire.sym} 1880 -2390 0 0 {name=l164 sig_type=std_logic lab=EN_buf}
C {ipin.sym} 800 -2880 0 0 {name=p80 lab=A<4>}
C {ipin.sym} 800 -2760 0 0 {name=p78 lab=A<3>}
C {lab_wire.sym} 550 -1970 0 0 {name=l569 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 550 -1950 0 0 {name=l570 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 550 -1930 0 0 {name=l571 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 550 -1910 0 0 {name=l572 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 550 -1890 0 0 {name=l573 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 550 -1870 0 0 {name=l574 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 550 -1850 0 0 {name=l575 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 550 -1830 0 0 {name=l576 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 550 -1810 0 0 {name=l577 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 550 -1790 0 0 {name=l578 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 550 -1770 0 0 {name=l579 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 550 -1750 0 0 {name=l580 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 550 -1730 0 0 {name=l581 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 550 -1710 0 0 {name=l582 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 550 -1690 0 0 {name=l583 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 550 -1670 0 0 {name=l584 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 550 -1650 0 0 {name=l585 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 550 -1630 0 0 {name=l586 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 550 -1610 0 0 {name=l587 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 550 -1590 0 0 {name=l588 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 550 -1570 0 0 {name=l589 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 550 -1550 0 0 {name=l590 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 550 -1530 0 0 {name=l591 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 550 -1510 0 0 {name=l592 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 550 -1490 0 0 {name=l593 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 550 -1470 0 0 {name=l594 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 550 -1450 0 0 {name=l595 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 550 -1430 0 0 {name=l596 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 550 -1410 0 0 {name=l597 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 550 -1390 0 0 {name=l598 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 550 -1350 0 0 {name=l599 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 550 -1370 0 0 {name=l600 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 890 -1970 2 0 {name=l601 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 890 -1950 2 0 {name=l602 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 890 -1930 2 0 {name=l603 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 890 -1910 2 0 {name=l604 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 890 -1890 2 0 {name=l605 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 890 -1870 2 0 {name=l606 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 890 -1850 2 0 {name=l607 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 890 -1830 2 0 {name=l608 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 890 -1810 2 0 {name=l609 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 890 -1790 2 0 {name=l610 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 890 -1770 2 0 {name=l611 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 890 -1750 2 0 {name=l612 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 890 -1730 2 0 {name=l613 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 890 -1710 2 0 {name=l614 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 890 -1690 2 0 {name=l615 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 890 -1670 2 0 {name=l616 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 890 -1650 2 0 {name=l617 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 890 -1630 2 0 {name=l618 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 890 -1610 2 0 {name=l619 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 890 -1590 2 0 {name=l620 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 890 -1570 2 0 {name=l621 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 890 -1550 2 0 {name=l622 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 890 -1530 2 0 {name=l623 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 890 -1510 2 0 {name=l624 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 890 -1490 2 0 {name=l625 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 890 -1470 2 0 {name=l626 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 890 -1450 2 0 {name=l627 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 890 -1430 2 0 {name=l628 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 890 -1410 2 0 {name=l629 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 890 -1390 2 0 {name=l630 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 890 -1370 2 0 {name=l631 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 890 -1350 2 0 {name=l632 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 720 -1270 0 0 {name=l143 sig_type=std_logic lab=A1}
C {lab_wire.sym} 740 -1270 0 0 {name=l147 sig_type=std_logic lab=A2}
C {lab_wire.sym} 700 -1270 0 0 {name=l151 sig_type=std_logic lab=A0}
C {lab_wire.sym} 640 -2080 0 0 {name=l155 sig_type=std_logic lab=CLK_RAM}
C {lab_wire.sym} 680 -2030 1 0 {name=l634 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 700 -2030 1 0 {name=l635 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 720 -2030 1 0 {name=l636 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 740 -2030 1 0 {name=l637 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 770 -2030 1 0 {name=l638 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 790 -2030 1 0 {name=l639 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 660 -2030 1 0 {name=l2443 sig_type=std_logic lab=Y0}
C {xschem_lib/sylee21/RAM8bit.sym} 2170 -1680 0 0 {name=RAM2}
C {lab_wire.sym} 2000 -1950 0 0 {name=l239 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2000 -1930 0 0 {name=l240 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2000 -1910 0 0 {name=l241 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2000 -1890 0 0 {name=l242 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2000 -1870 0 0 {name=l243 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2000 -1850 0 0 {name=l244 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2000 -1830 0 0 {name=l245 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2000 -1810 0 0 {name=l246 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2000 -1790 0 0 {name=l247 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2000 -1770 0 0 {name=l248 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2000 -1750 0 0 {name=l249 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2000 -1730 0 0 {name=l250 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2000 -1710 0 0 {name=l251 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2000 -1690 0 0 {name=l252 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2000 -1670 0 0 {name=l253 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2000 -1650 0 0 {name=l254 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2000 -1630 0 0 {name=l255 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2000 -1610 0 0 {name=l256 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2000 -1590 0 0 {name=l257 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2000 -1570 0 0 {name=l258 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2000 -1550 0 0 {name=l259 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2000 -1530 0 0 {name=l260 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2000 -1510 0 0 {name=l261 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2000 -1490 0 0 {name=l262 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2000 -1470 0 0 {name=l263 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2000 -1450 0 0 {name=l264 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2000 -1430 0 0 {name=l265 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2000 -1410 0 0 {name=l266 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2000 -1390 0 0 {name=l267 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2000 -1370 0 0 {name=l268 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2000 -1330 0 0 {name=l269 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2000 -1350 0 0 {name=l270 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2340 -1950 2 0 {name=l271 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2340 -1930 2 0 {name=l272 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2340 -1910 2 0 {name=l273 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2340 -1890 2 0 {name=l274 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2340 -1870 2 0 {name=l275 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2340 -1850 2 0 {name=l276 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2340 -1830 2 0 {name=l277 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2340 -1810 2 0 {name=l278 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2340 -1790 2 0 {name=l279 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2340 -1770 2 0 {name=l280 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2340 -1750 2 0 {name=l281 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2340 -1730 2 0 {name=l282 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2340 -1710 2 0 {name=l283 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2340 -1690 2 0 {name=l284 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2340 -1670 2 0 {name=l285 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2340 -1650 2 0 {name=l286 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2340 -1630 2 0 {name=l287 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2340 -1610 2 0 {name=l288 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2340 -1590 2 0 {name=l289 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2340 -1570 2 0 {name=l290 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2340 -1550 2 0 {name=l291 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2340 -1530 2 0 {name=l292 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2340 -1510 2 0 {name=l293 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2340 -1490 2 0 {name=l294 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2340 -1470 2 0 {name=l295 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2340 -1450 2 0 {name=l296 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2340 -1430 2 0 {name=l297 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2340 -1410 2 0 {name=l298 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2340 -1390 2 0 {name=l299 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2340 -1370 2 0 {name=l300 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2340 -1350 2 0 {name=l301 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2340 -1330 2 0 {name=l302 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2170 -1250 0 0 {name=l303 sig_type=std_logic lab=A1}
C {lab_wire.sym} 2190 -1250 0 0 {name=l304 sig_type=std_logic lab=A2}
C {lab_wire.sym} 2150 -1250 0 0 {name=l305 sig_type=std_logic lab=A0}
C {lab_wire.sym} 2090 -2060 0 0 {name=l306 sig_type=std_logic lab=CLK_RAM}
C {lab_wire.sym} 2130 -2010 1 0 {name=l307 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2150 -2010 1 0 {name=l308 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2170 -2010 1 0 {name=l309 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2190 -2010 1 0 {name=l310 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2220 -2010 1 0 {name=l311 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2240 -2010 1 0 {name=l312 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2110 -2010 1 0 {name=l313 sig_type=std_logic lab=Y2}
C {xschem_lib/sylee21/RAM8bit.sym} 2940 -1690 0 0 {name=RAM3}
C {lab_wire.sym} 2770 -1960 0 0 {name=l314 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2770 -1940 0 0 {name=l315 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2770 -1920 0 0 {name=l316 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2770 -1900 0 0 {name=l317 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2770 -1880 0 0 {name=l318 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2770 -1860 0 0 {name=l319 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2770 -1840 0 0 {name=l320 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2770 -1820 0 0 {name=l321 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2770 -1800 0 0 {name=l322 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2770 -1780 0 0 {name=l323 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2770 -1760 0 0 {name=l324 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2770 -1740 0 0 {name=l325 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2770 -1720 0 0 {name=l326 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2770 -1700 0 0 {name=l327 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2770 -1680 0 0 {name=l328 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2770 -1660 0 0 {name=l329 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2770 -1640 0 0 {name=l330 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2770 -1620 0 0 {name=l331 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2770 -1600 0 0 {name=l332 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2770 -1580 0 0 {name=l333 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2770 -1560 0 0 {name=l334 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2770 -1540 0 0 {name=l335 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2770 -1520 0 0 {name=l336 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2770 -1500 0 0 {name=l337 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2770 -1480 0 0 {name=l338 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2770 -1460 0 0 {name=l339 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2770 -1440 0 0 {name=l340 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2770 -1420 0 0 {name=l341 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2770 -1400 0 0 {name=l342 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2770 -1380 0 0 {name=l343 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2770 -1340 0 0 {name=l344 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2770 -1360 0 0 {name=l345 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3110 -1960 2 0 {name=l346 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3110 -1940 2 0 {name=l347 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3110 -1920 2 0 {name=l348 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3110 -1900 2 0 {name=l349 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3110 -1880 2 0 {name=l350 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3110 -1860 2 0 {name=l351 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3110 -1840 2 0 {name=l352 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3110 -1820 2 0 {name=l353 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3110 -1800 2 0 {name=l354 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3110 -1780 2 0 {name=l355 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3110 -1760 2 0 {name=l356 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3110 -1740 2 0 {name=l357 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3110 -1720 2 0 {name=l358 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3110 -1700 2 0 {name=l359 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3110 -1680 2 0 {name=l360 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3110 -1660 2 0 {name=l361 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3110 -1640 2 0 {name=l362 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3110 -1620 2 0 {name=l363 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3110 -1600 2 0 {name=l364 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3110 -1580 2 0 {name=l365 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3110 -1560 2 0 {name=l366 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3110 -1540 2 0 {name=l367 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3110 -1520 2 0 {name=l368 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3110 -1500 2 0 {name=l369 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3110 -1480 2 0 {name=l370 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3110 -1460 2 0 {name=l371 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3110 -1440 2 0 {name=l372 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3110 -1420 2 0 {name=l373 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3110 -1400 2 0 {name=l374 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3110 -1380 2 0 {name=l375 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3110 -1360 2 0 {name=l376 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3110 -1340 2 0 {name=l377 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2940 -1260 0 0 {name=l378 sig_type=std_logic lab=A1}
C {lab_wire.sym} 2960 -1260 0 0 {name=l379 sig_type=std_logic lab=A2}
C {lab_wire.sym} 2920 -1260 0 0 {name=l380 sig_type=std_logic lab=A0}
C {lab_wire.sym} 2860 -2070 0 0 {name=l381 sig_type=std_logic lab=CLK_RAM}
C {lab_wire.sym} 2900 -2020 1 0 {name=l382 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2920 -2020 1 0 {name=l383 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2940 -2020 1 0 {name=l384 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2960 -2020 1 0 {name=l385 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2990 -2020 1 0 {name=l386 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3010 -2020 1 0 {name=l387 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2880 -2020 1 0 {name=l388 sig_type=std_logic lab=Y3}
C {lab_wire.sym} 2470 -2420 0 0 {name=l389 sig_type=std_logic lab=Y0}
C {lab_wire.sym} 2470 -2400 0 0 {name=l390 sig_type=std_logic lab=Y1}
C {lab_wire.sym} 2470 -2380 0 0 {name=l391 sig_type=std_logic lab=Y2}
C {lab_wire.sym} 2470 -2360 0 0 {name=l392 sig_type=std_logic lab=Y3}
C {lab_wire.sym} 2240 -2350 0 0 {name=l393 sig_type=std_logic lab=EN_buf}
C {lab_wire.sym} 2240 -2370 0 0 {name=l394 sig_type=std_logic lab=A4}
C {lab_wire.sym} 2240 -2390 0 0 {name=l395 sig_type=std_logic lab=A3}
C {xschem_lib/sylee21/DFF.sym} 3890 -1130 0 0 {name=xDFF1 NF=2}
C {lab_wire.sym} 3760 -1140 0 0 {name=l396 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3860 -1060 0 0 {name=l397 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3860 -1200 0 0 {name=l398 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 -1120 0 0 {name=l399 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4000 -1130 0 0 {name=l400 sig_type=std_logic lab=Do<8>}
C {xschem_lib/sylee21/DFF.sym} 4630 -1130 0 0 {name=xDFF2 NF=2}
C {lab_wire.sym} 4500 -1140 0 0 {name=l401 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 4600 -1060 0 0 {name=l402 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4600 -1200 0 0 {name=l403 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4500 -1120 0 0 {name=l404 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4740 -1130 0 0 {name=l405 sig_type=std_logic lab=Do<10>}
C {xschem_lib/sylee21/DFF.sym} 3890 -940 0 0 {name=xDFF3 NF=2}
C {lab_wire.sym} 3760 -950 0 0 {name=l406 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3860 -870 0 0 {name=l407 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3860 -1010 0 0 {name=l408 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 -930 0 0 {name=l409 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4000 -940 0 0 {name=l410 sig_type=std_logic lab=Do<12>}
C {xschem_lib/sylee21/DFF.sym} 4630 -940 0 0 {name=xDFF4 NF=2}
C {lab_wire.sym} 4500 -950 0 0 {name=l411 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 4600 -870 0 0 {name=l412 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4600 -1010 0 0 {name=l413 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4500 -930 0 0 {name=l414 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4740 -940 0 0 {name=l415 sig_type=std_logic lab=Do<14>}
C {xschem_lib/sylee21/DFF.sym} 3890 -750 0 0 {name=xDFF5 NF=2}
C {lab_wire.sym} 3760 -760 0 0 {name=l416 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3860 -680 0 0 {name=l417 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3860 -820 0 0 {name=l418 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 -740 0 0 {name=l419 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4000 -750 0 0 {name=l420 sig_type=std_logic lab=Do<16>}
C {xschem_lib/sylee21/DFF.sym} 4630 -750 0 0 {name=xDFF6 NF=2}
C {lab_wire.sym} 4500 -760 0 0 {name=l421 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 4600 -680 0 0 {name=l422 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4600 -820 0 0 {name=l423 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4500 -740 0 0 {name=l424 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4740 -750 0 0 {name=l425 sig_type=std_logic lab=Do<18>}
C {xschem_lib/sylee21/DFF.sym} 3890 -560 0 0 {name=xDFF7 NF=2}
C {lab_wire.sym} 3760 -570 0 0 {name=l426 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3860 -490 0 0 {name=l427 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3860 -630 0 0 {name=l428 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 -550 0 0 {name=l429 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4000 -560 0 0 {name=l430 sig_type=std_logic lab=Do<20>}
C {xschem_lib/sylee21/DFF.sym} 4630 -560 0 0 {name=xDFF8 NF=2}
C {lab_wire.sym} 4500 -570 0 0 {name=l431 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 4600 -490 0 0 {name=l432 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4600 -630 0 0 {name=l433 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4500 -550 0 0 {name=l434 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4740 -560 0 0 {name=l435 sig_type=std_logic lab=Do<22>}
C {xschem_lib/sylee21/DFF.sym} 3890 -370 0 0 {name=xDFF9 NF=2}
C {lab_wire.sym} 3760 -380 0 0 {name=l436 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3860 -300 0 0 {name=l437 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3860 -440 0 0 {name=l438 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 -360 0 0 {name=l439 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4000 -370 0 0 {name=l440 sig_type=std_logic lab=Do<24>}
C {xschem_lib/sylee21/DFF.sym} 4630 -370 0 0 {name=xDFF10 NF=2}
C {lab_wire.sym} 4500 -380 0 0 {name=l441 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 4600 -300 0 0 {name=l442 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4600 -440 0 0 {name=l443 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4500 -360 0 0 {name=l444 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4740 -370 0 0 {name=l445 sig_type=std_logic lab=Do<26>}
C {xschem_lib/sylee21/DFF.sym} 3890 -180 0 0 {name=xDFF11 NF=2}
C {lab_wire.sym} 3760 -190 0 0 {name=l446 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3860 -110 0 0 {name=l447 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3860 -250 0 0 {name=l448 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 -170 0 0 {name=l449 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4000 -180 0 0 {name=l450 sig_type=std_logic lab=Do<28>}
C {xschem_lib/sylee21/DFF.sym} 4630 -180 0 0 {name=xDFF12 NF=2}
C {lab_wire.sym} 4500 -190 0 0 {name=l451 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 4600 -110 0 0 {name=l452 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4600 -250 0 0 {name=l453 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4500 -170 0 0 {name=l454 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4740 -180 0 0 {name=l455 sig_type=std_logic lab=Do<30>}
C {xschem_lib/sylee21/DFF.sym} 3890 -1510 0 0 {name=xDFF13 NF=2}
C {lab_wire.sym} 3760 -1520 0 0 {name=l456 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3860 -1440 0 0 {name=l457 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3860 -1580 0 0 {name=l458 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 -1500 0 0 {name=l459 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4000 -1510 0 0 {name=l460 sig_type=std_logic lab=Do<0>}
C {xschem_lib/sylee21/DFF.sym} 4630 -1510 0 0 {name=xDFF14 NF=2}
C {lab_wire.sym} 4500 -1520 0 0 {name=l461 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 4600 -1440 0 0 {name=l462 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4600 -1580 0 0 {name=l463 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4500 -1500 0 0 {name=l464 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4740 -1510 0 0 {name=l465 sig_type=std_logic lab=Do<2>}
C {xschem_lib/sylee21/DFF.sym} 3890 -1320 0 0 {name=xDFF15 NF=2}
C {lab_wire.sym} 3760 -1330 0 0 {name=l466 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3860 -1250 0 0 {name=l467 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3860 -1390 0 0 {name=l468 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 -1310 0 0 {name=l469 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4000 -1320 0 0 {name=l470 sig_type=std_logic lab=Do<4>}
C {xschem_lib/sylee21/DFF.sym} 4630 -1320 0 0 {name=xDFF16 NF=2}
C {lab_wire.sym} 4500 -1330 0 0 {name=l471 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 4600 -1250 0 0 {name=l472 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4600 -1390 0 0 {name=l473 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4500 -1310 0 0 {name=l474 sig_type=std_logic lab=CLK_outreg0}
C {lab_wire.sym} 4740 -1320 0 0 {name=l475 sig_type=std_logic lab=Do<6>}
C {xschem_lib/sylee21/DFF.sym} 5010 -1510 0 0 {name=xDFF17 NF=2}
C {lab_wire.sym} 4880 -1520 0 0 {name=l476 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 4980 -1440 0 0 {name=l477 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4980 -1580 0 0 {name=l478 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4880 -1500 0 0 {name=l479 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 5120 -1510 0 0 {name=l480 sig_type=std_logic lab=Do<3>}
C {xschem_lib/sylee21/DFF.sym} 4260 -1510 0 0 {name=xDFF18 NF=2}
C {lab_wire.sym} 4130 -1520 0 0 {name=l481 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 4230 -1440 0 0 {name=l482 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4230 -1580 0 0 {name=l483 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -1500 0 0 {name=l484 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 4370 -1510 0 0 {name=l485 sig_type=std_logic lab=Do<1>}
C {xschem_lib/sylee21/DFF.sym} 5010 -1320 0 0 {name=xDFF19 NF=2}
C {lab_wire.sym} 4880 -1330 0 0 {name=l486 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 4980 -1250 0 0 {name=l487 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4980 -1390 0 0 {name=l488 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4880 -1310 0 0 {name=l489 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 5120 -1320 0 0 {name=l490 sig_type=std_logic lab=Do<7>}
C {xschem_lib/sylee21/DFF.sym} 4260 -1320 0 0 {name=xDFF20 NF=2}
C {lab_wire.sym} 4130 -1330 0 0 {name=l491 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 4230 -1250 0 0 {name=l492 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4230 -1390 0 0 {name=l493 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -1310 0 0 {name=l494 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 4370 -1320 0 0 {name=l495 sig_type=std_logic lab=Do<5>}
C {xschem_lib/sylee21/DFF.sym} 5010 -1130 0 0 {name=xDFF21 NF=2}
C {lab_wire.sym} 4880 -1140 0 0 {name=l496 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 4980 -1060 0 0 {name=l497 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4980 -1200 0 0 {name=l498 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4880 -1120 0 0 {name=l499 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 5120 -1130 0 0 {name=l500 sig_type=std_logic lab=Do<11>}
C {xschem_lib/sylee21/DFF.sym} 4260 -1130 0 0 {name=xDFF22 NF=2}
C {lab_wire.sym} 4130 -1140 0 0 {name=l501 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 4230 -1060 0 0 {name=l502 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4230 -1200 0 0 {name=l503 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -1120 0 0 {name=l504 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 4370 -1130 0 0 {name=l505 sig_type=std_logic lab=Do<9>}
C {xschem_lib/sylee21/DFF.sym} 5010 -940 0 0 {name=xDFF23 NF=2}
C {lab_wire.sym} 4880 -950 0 0 {name=l506 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 4980 -870 0 0 {name=l507 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4980 -1010 0 0 {name=l508 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4880 -930 0 0 {name=l509 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 5120 -940 0 0 {name=l510 sig_type=std_logic lab=Do<15>}
C {xschem_lib/sylee21/DFF.sym} 4260 -940 0 0 {name=xDFF24 NF=2}
C {lab_wire.sym} 4130 -950 0 0 {name=l511 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 4230 -870 0 0 {name=l512 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4230 -1010 0 0 {name=l513 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -930 0 0 {name=l514 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 4370 -940 0 0 {name=l515 sig_type=std_logic lab=Do<13>}
C {xschem_lib/sylee21/DFF.sym} 5010 -750 0 0 {name=xDFF25 NF=2}
C {lab_wire.sym} 4880 -760 0 0 {name=l516 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 4980 -680 0 0 {name=l517 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4980 -820 0 0 {name=l518 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4880 -740 0 0 {name=l519 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 5120 -750 0 0 {name=l520 sig_type=std_logic lab=Do<19>}
C {xschem_lib/sylee21/DFF.sym} 4260 -750 0 0 {name=xDFF26 NF=2}
C {lab_wire.sym} 4130 -760 0 0 {name=l521 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 4230 -680 0 0 {name=l522 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4230 -820 0 0 {name=l523 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -740 0 0 {name=l524 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 4370 -750 0 0 {name=l525 sig_type=std_logic lab=Do<17>}
C {xschem_lib/sylee21/DFF.sym} 5010 -560 0 0 {name=xDFF27 NF=2}
C {lab_wire.sym} 4880 -570 0 0 {name=l526 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 4980 -490 0 0 {name=l527 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4980 -630 0 0 {name=l528 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4880 -550 0 0 {name=l529 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 5120 -560 0 0 {name=l530 sig_type=std_logic lab=Do<23>}
C {xschem_lib/sylee21/DFF.sym} 4260 -560 0 0 {name=xDFF28 NF=2}
C {lab_wire.sym} 4130 -570 0 0 {name=l531 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 4230 -490 0 0 {name=l532 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4230 -630 0 0 {name=l533 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -550 0 0 {name=l534 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 4370 -560 0 0 {name=l535 sig_type=std_logic lab=Do<21>}
C {xschem_lib/sylee21/DFF.sym} 5010 -370 0 0 {name=xDFF29 NF=2}
C {lab_wire.sym} 4880 -380 0 0 {name=l536 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 4980 -300 0 0 {name=l537 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4980 -440 0 0 {name=l538 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4880 -360 0 0 {name=l539 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 5120 -370 0 0 {name=l540 sig_type=std_logic lab=Do<27>}
C {xschem_lib/sylee21/DFF.sym} 4260 -370 0 0 {name=xDFF30 NF=2}
C {lab_wire.sym} 4130 -380 0 0 {name=l541 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 4230 -300 0 0 {name=l542 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4230 -440 0 0 {name=l543 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -360 0 0 {name=l544 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 4370 -370 0 0 {name=l545 sig_type=std_logic lab=Do<25>}
C {xschem_lib/sylee21/DFF.sym} 5010 -180 0 0 {name=xDFF31 NF=2}
C {lab_wire.sym} 4880 -190 0 0 {name=l546 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 4980 -110 0 0 {name=l547 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4980 -250 0 0 {name=l548 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4880 -170 0 0 {name=l549 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 5120 -180 0 0 {name=l550 sig_type=std_logic lab=Do<31>}
C {xschem_lib/sylee21/DFF.sym} 4260 -180 0 0 {name=xDFF32 NF=2}
C {lab_wire.sym} 4130 -190 0 0 {name=l551 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 4230 -110 0 0 {name=l552 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4230 -250 0 0 {name=l553 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -170 0 0 {name=l554 sig_type=std_logic lab=CLK_outreg1}
C {lab_wire.sym} 4370 -180 0 0 {name=l555 sig_type=std_logic lab=Do<29>}
C {ipin.sym} 1010 -680 0 0 {name=p68 lab=EN}
C {xschem_lib/sylee21/RAM8bit.sym} 1450 -1680 0 0 {name=RAM1}
C {lab_wire.sym} 1280 -1950 0 0 {name=l159 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1280 -1930 0 0 {name=l165 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1280 -1910 0 0 {name=l166 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1280 -1890 0 0 {name=l167 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1280 -1870 0 0 {name=l168 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1280 -1850 0 0 {name=l169 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1280 -1830 0 0 {name=l170 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1280 -1810 0 0 {name=l171 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1280 -1790 0 0 {name=l172 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1280 -1770 0 0 {name=l173 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1280 -1750 0 0 {name=l174 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1280 -1730 0 0 {name=l175 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1280 -1710 0 0 {name=l176 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1280 -1690 0 0 {name=l177 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1280 -1670 0 0 {name=l178 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1280 -1650 0 0 {name=l179 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1280 -1630 0 0 {name=l180 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1280 -1610 0 0 {name=l181 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1280 -1590 0 0 {name=l182 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1280 -1570 0 0 {name=l183 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1280 -1550 0 0 {name=l184 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1280 -1530 0 0 {name=l185 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1280 -1510 0 0 {name=l186 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1280 -1490 0 0 {name=l187 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1280 -1470 0 0 {name=l188 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1280 -1450 0 0 {name=l189 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1280 -1430 0 0 {name=l190 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1280 -1410 0 0 {name=l191 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1280 -1390 0 0 {name=l192 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1280 -1370 0 0 {name=l193 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1280 -1330 0 0 {name=l194 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1280 -1350 0 0 {name=l195 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1620 -1950 2 0 {name=l196 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1620 -1930 2 0 {name=l197 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1620 -1910 2 0 {name=l198 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1620 -1890 2 0 {name=l199 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1620 -1870 2 0 {name=l200 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1620 -1850 2 0 {name=l201 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1620 -1830 2 0 {name=l202 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1620 -1810 2 0 {name=l203 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1620 -1790 2 0 {name=l204 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1620 -1770 2 0 {name=l205 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1620 -1750 2 0 {name=l206 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1620 -1730 2 0 {name=l207 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1620 -1710 2 0 {name=l208 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1620 -1690 2 0 {name=l209 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1620 -1670 2 0 {name=l210 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1620 -1650 2 0 {name=l211 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1620 -1630 2 0 {name=l212 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1620 -1610 2 0 {name=l213 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1620 -1590 2 0 {name=l214 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1620 -1570 2 0 {name=l215 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1620 -1550 2 0 {name=l216 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1620 -1530 2 0 {name=l217 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1620 -1510 2 0 {name=l218 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1620 -1490 2 0 {name=l219 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1620 -1470 2 0 {name=l220 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1620 -1450 2 0 {name=l221 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1620 -1430 2 0 {name=l222 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1620 -1410 2 0 {name=l223 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1620 -1390 2 0 {name=l224 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1620 -1370 2 0 {name=l225 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1620 -1350 2 0 {name=l226 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1620 -1330 2 0 {name=l227 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1450 -1250 0 0 {name=l228 sig_type=std_logic lab=A1}
C {lab_wire.sym} 1470 -1250 0 0 {name=l229 sig_type=std_logic lab=A2}
C {lab_wire.sym} 1430 -1250 0 0 {name=l230 sig_type=std_logic lab=A0}
C {lab_wire.sym} 1370 -2060 0 0 {name=l231 sig_type=std_logic lab=CLK_RAM}
C {lab_wire.sym} 1410 -2010 1 0 {name=l232 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1430 -2010 1 0 {name=l233 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1450 -2010 1 0 {name=l234 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1470 -2010 1 0 {name=l235 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1500 -2010 1 0 {name=l236 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1520 -2010 1 0 {name=l237 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1390 -2010 1 0 {name=l238 sig_type=std_logic lab=Y1}
