v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {WORD x 32} 1290 -2310 0 0 5 5 {}
T {BUF_SEL} -2810 -220 0 0 4 4 {}
T {BUF_IN} -2670 910 0 0 4 4 {}
T {BUF_CLK} -1990 -2360 0 0 3 3 {}
T {BUF_WE} -890 -1740 0 0 2 2 {}
T {PINS} -760 -2870 0 0 3 3 {}
T {DEC2to4 x1
DEC3to8 x4} -2850 -1420 0 0 3 3 {}
N -1780 -1300 -1760 -1300 {
lab=A3}
N -1780 -1280 -1760 -1280 {
lab=A4}
N -1780 -1260 -1760 -1260 {
lab=EN}
N -1600 -1330 -1590 -1330 {
lab=#net1}
N -1600 -1310 -1590 -1310 {
lab=#net2}
N -1600 -1290 -1590 -1290 {
lab=#net3}
N -1600 -1270 -1590 -1270 {
lab=#net4}
N -1590 -1680 -1590 -1330 {
lab=#net1}
N -1590 -1680 -1340 -1680 {
lab=#net1}
N -1560 -1430 -1340 -1430 {
lab=#net2}
N -1560 -1430 -1560 -1310 {
lab=#net2}
N -1590 -1310 -1560 -1310 {
lab=#net2}
N -1560 -1180 -1340 -1180 {
lab=#net3}
N -1560 -1290 -1560 -1180 {
lab=#net3}
N -1590 -1290 -1560 -1290 {
lab=#net3}
N -1590 -1270 -1590 -920 {
lab=#net4}
N -1590 -920 -1340 -920 {
lab=#net4}
N -1420 -1660 -1340 -1660 {
lab=A2}
N -1420 -1660 -1420 -900 {
lab=A2}
N -1420 -900 -1340 -900 {
lab=A2}
N -1420 -1160 -1340 -1160 {
lab=A2}
N -1420 -1410 -1340 -1410 {
lab=A2}
N -1400 -1640 -1340 -1640 {
lab=A1}
N -1460 -1640 -1400 -1640 {
lab=A1}
N -1460 -1640 -1460 -880 {
lab=A1}
N -1460 -880 -1340 -880 {
lab=A1}
N -1460 -1140 -1340 -1140 {
lab=A1}
N -1460 -1390 -1340 -1390 {
lab=A1}
N -1500 -1620 -1340 -1620 {
lab=A0}
N -1500 -1620 -1500 -860 {
lab=A0}
N -1500 -860 -1340 -860 {
lab=A0}
N -1500 -1370 -1340 -1370 {
lab=A0}
N -1500 -1120 -1340 -1120 {
lab=A0}
N -1780 -1160 -1420 -1160 {
lab=A2}
N -1780 -1140 -1460 -1140 {
lab=A1}
N -1780 -1120 -1500 -1120 {
lab=A0}
N -1350 -1740 -1340 -1740 {
lab=VDD}
N -1350 -1720 -1340 -1720 {
lab=VSS}
N -1350 -1490 -1340 -1490 {
lab=VDD}
N -1350 -1470 -1340 -1470 {
lab=VSS}
N -1350 -1240 -1340 -1240 {
lab=VDD}
N -1350 -1220 -1340 -1220 {
lab=VSS}
N -1350 -980 -1340 -980 {
lab=VDD}
N -1350 -960 -1340 -960 {
lab=VSS}
N -1770 -1340 -1760 -1340 {
lab=VDD}
N -1770 -1320 -1760 -1320 {
lab=VSS}
N -1350 -1740 -1340 -1740 {
lab=VDD}
N -1350 -1720 -1340 -1720 {
lab=VSS}
N -1350 -1490 -1340 -1490 {
lab=VDD}
N -1350 -1470 -1340 -1470 {
lab=VSS}
N -1350 -1240 -1340 -1240 {
lab=VDD}
N -1350 -1220 -1340 -1220 {
lab=VSS}
N -1350 -980 -1340 -980 {
lab=VDD}
N -1350 -960 -1340 -960 {
lab=VSS}
N -1620 -640 -1600 -640 {
lab=#net5}
N -1700 -680 -1540 -680 {
lab=VDD}
N -1700 -600 -1540 -600 {
lab=VSS}
N -1170 -1750 -1150 -1750 {
lab=Y0}
N -1170 -1730 -1150 -1730 {
lab=Y1}
N -1170 -1710 -1150 -1710 {
lab=Y2}
N -1170 -1690 -1150 -1690 {
lab=Y3}
N -1170 -1670 -1150 -1670 {
lab=Y4}
N -1170 -1650 -1150 -1650 {
lab=Y5}
N -1170 -1630 -1150 -1630 {
lab=Y6}
N -1170 -1610 -1150 -1610 {
lab=Y7}
N -1170 -1500 -1150 -1500 {
lab=Y8}
N -1170 -1480 -1150 -1480 {
lab=Y9}
N -1170 -1460 -1150 -1460 {
lab=Y10}
N -1170 -1440 -1150 -1440 {
lab=Y11}
N -1170 -1420 -1150 -1420 {
lab=Y12}
N -1170 -1400 -1150 -1400 {
lab=Y13}
N -1170 -1380 -1150 -1380 {
lab=Y14}
N -1170 -1360 -1150 -1360 {
lab=Y15}
N -1170 -1250 -1150 -1250 {
lab=Y16}
N -1170 -1230 -1150 -1230 {
lab=Y17}
N -1170 -1210 -1150 -1210 {
lab=Y18}
N -1170 -1190 -1150 -1190 {
lab=Y19}
N -1170 -1170 -1150 -1170 {
lab=Y20}
N -1170 -1150 -1150 -1150 {
lab=Y21}
N -1170 -1130 -1150 -1130 {
lab=Y22}
N -1170 -1110 -1150 -1110 {
lab=Y23}
N -1170 -990 -1150 -990 {
lab=Y24}
N -1170 -970 -1150 -970 {
lab=Y25}
N -1170 -950 -1150 -950 {
lab=Y26}
N -1170 -930 -1150 -930 {
lab=Y27}
N -1170 -910 -1150 -910 {
lab=Y28}
N -1170 -890 -1150 -890 {
lab=Y29}
N -1170 -870 -1150 -870 {
lab=Y30}
N -1170 -850 -1150 -850 {
lab=Y31}
N -1460 -640 -1440 -640 {
lab=SEL[0]}
N -1770 -640 -1760 -640 {
lab=Y0}
N -1260 -640 -1240 -640 {
lab=#net6}
N -1340 -680 -1180 -680 {
lab=VDD}
N -1340 -600 -1180 -600 {
lab=VSS}
N -1100 -640 -1080 -640 {
lab=SEL[1]}
N -1410 -640 -1400 -640 {
lab=Y1}
N -880 -640 -860 -640 {
lab=#net7}
N -960 -680 -800 -680 {
lab=VDD}
N -960 -600 -800 -600 {
lab=VSS}
N -720 -640 -700 -640 {
lab=SEL[2]}
N -1030 -640 -1020 -640 {
lab=Y2}
N -520 -640 -500 -640 {
lab=#net8}
N -600 -680 -440 -680 {
lab=VDD}
N -600 -600 -440 -600 {
lab=VSS}
N -360 -640 -340 -640 {
lab=SEL[3]}
N -670 -640 -660 -640 {
lab=Y3}
N -1620 -470 -1600 -470 {
lab=#net9}
N -1700 -510 -1540 -510 {
lab=VDD}
N -1700 -430 -1540 -430 {
lab=VSS}
N -1460 -470 -1440 -470 {
lab=SEL[4]}
N -1770 -470 -1760 -470 {
lab=Y4}
N -1260 -470 -1240 -470 {
lab=#net10}
N -1340 -510 -1180 -510 {
lab=VDD}
N -1340 -430 -1180 -430 {
lab=VSS}
N -1100 -470 -1080 -470 {
lab=SEL[5]}
N -1410 -470 -1400 -470 {
lab=Y5}
N -880 -470 -860 -470 {
lab=#net11}
N -960 -510 -800 -510 {
lab=VDD}
N -960 -430 -800 -430 {
lab=VSS}
N -720 -470 -700 -470 {
lab=SEL[6]}
N -1030 -470 -1020 -470 {
lab=Y6}
N -520 -470 -500 -470 {
lab=#net12}
N -600 -510 -440 -510 {
lab=VDD}
N -600 -430 -440 -430 {
lab=VSS}
N -360 -470 -340 -470 {
lab=SEL[7]}
N -670 -470 -660 -470 {
lab=Y7}
N -1630 -300 -1610 -300 {
lab=#net13}
N -1710 -340 -1550 -340 {
lab=VDD}
N -1710 -260 -1550 -260 {
lab=VSS}
N -1470 -300 -1450 -300 {
lab=SEL[8]}
N -1780 -300 -1770 -300 {
lab=Y8}
N -1270 -300 -1250 -300 {
lab=#net14}
N -1350 -340 -1190 -340 {
lab=VDD}
N -1350 -260 -1190 -260 {
lab=VSS}
N -1110 -300 -1090 -300 {
lab=SEL[9]}
N -1420 -300 -1410 -300 {
lab=Y9}
N -890 -300 -870 -300 {
lab=#net15}
N -970 -340 -810 -340 {
lab=VDD}
N -970 -260 -810 -260 {
lab=VSS}
N -730 -300 -710 -300 {
lab=SEL[10]}
N -1040 -300 -1030 -300 {
lab=Y10}
N -530 -300 -510 -300 {
lab=#net16}
N -610 -340 -450 -340 {
lab=VDD}
N -610 -260 -450 -260 {
lab=VSS}
N -370 -300 -350 -300 {
lab=SEL[11]}
N -680 -300 -670 -300 {
lab=Y11}
N -1630 -130 -1610 -130 {
lab=#net17}
N -1710 -170 -1550 -170 {
lab=VDD}
N -1710 -90 -1550 -90 {
lab=VSS}
N -1470 -130 -1450 -130 {
lab=SEL[12]}
N -1780 -130 -1770 -130 {
lab=Y12}
N -1270 -130 -1250 -130 {
lab=#net18}
N -1350 -170 -1190 -170 {
lab=VDD}
N -1350 -90 -1190 -90 {
lab=VSS}
N -1110 -130 -1090 -130 {
lab=SEL[13]}
N -1420 -130 -1410 -130 {
lab=Y13}
N -890 -130 -870 -130 {
lab=#net19}
N -970 -170 -810 -170 {
lab=VDD}
N -970 -90 -810 -90 {
lab=VSS}
N -730 -130 -710 -130 {
lab=SEL[14]}
N -1040 -130 -1030 -130 {
lab=Y14}
N -530 -130 -510 -130 {
lab=#net20}
N -610 -170 -450 -170 {
lab=VDD}
N -610 -90 -450 -90 {
lab=VSS}
N -370 -130 -350 -130 {
lab=SEL[15]}
N -680 -130 -670 -130 {
lab=Y15}
N -1620 40 -1600 40 {
lab=#net21}
N -1700 0 -1540 0 {
lab=VDD}
N -1700 80 -1540 80 {
lab=VSS}
N -1460 40 -1440 40 {
lab=SEL[16]}
N -1770 40 -1760 40 {
lab=Y16}
N -1260 40 -1240 40 {
lab=#net22}
N -1340 0 -1180 0 {
lab=VDD}
N -1340 80 -1180 80 {
lab=VSS}
N -1100 40 -1080 40 {
lab=SEL[17]}
N -1410 40 -1400 40 {
lab=Y17}
N -880 40 -860 40 {
lab=#net23}
N -960 0 -800 0 {
lab=VDD}
N -960 80 -800 80 {
lab=VSS}
N -720 40 -700 40 {
lab=SEL[18]}
N -1030 40 -1020 40 {
lab=Y18}
N -520 40 -500 40 {
lab=#net24}
N -600 0 -440 0 {
lab=VDD}
N -600 80 -440 80 {
lab=VSS}
N -360 40 -340 40 {
lab=SEL[19]}
N -670 40 -660 40 {
lab=Y19}
N -1620 210 -1600 210 {
lab=#net25}
N -1700 170 -1540 170 {
lab=VDD}
N -1700 250 -1540 250 {
lab=VSS}
N -1460 210 -1440 210 {
lab=SEL[20]}
N -1770 210 -1760 210 {
lab=Y20}
N -1260 210 -1240 210 {
lab=#net26}
N -1340 170 -1180 170 {
lab=VDD}
N -1340 250 -1180 250 {
lab=VSS}
N -1100 210 -1080 210 {
lab=SEL[21]}
N -1410 210 -1400 210 {
lab=Y21}
N -880 210 -860 210 {
lab=#net27}
N -960 170 -800 170 {
lab=VDD}
N -960 250 -800 250 {
lab=VSS}
N -720 210 -700 210 {
lab=SEL[22]}
N -1030 210 -1020 210 {
lab=Y22}
N -520 210 -500 210 {
lab=#net28}
N -600 170 -440 170 {
lab=VDD}
N -600 250 -440 250 {
lab=VSS}
N -360 210 -340 210 {
lab=SEL[23]}
N -670 210 -660 210 {
lab=Y23}
N -1620 380 -1600 380 {
lab=#net29}
N -1700 340 -1540 340 {
lab=VDD}
N -1700 420 -1540 420 {
lab=VSS}
N -1460 380 -1440 380 {
lab=SEL[24]}
N -1770 380 -1760 380 {
lab=Y24}
N -1260 380 -1240 380 {
lab=#net30}
N -1340 340 -1180 340 {
lab=VDD}
N -1340 420 -1180 420 {
lab=VSS}
N -1100 380 -1080 380 {
lab=SEL[25]}
N -1410 380 -1400 380 {
lab=Y25}
N -880 380 -860 380 {
lab=#net31}
N -960 340 -800 340 {
lab=VDD}
N -960 420 -800 420 {
lab=VSS}
N -720 380 -700 380 {
lab=SEL[26]}
N -1030 380 -1020 380 {
lab=Y26}
N -520 380 -500 380 {
lab=#net32}
N -600 340 -440 340 {
lab=VDD}
N -600 420 -440 420 {
lab=VSS}
N -360 380 -340 380 {
lab=SEL[27]}
N -670 380 -660 380 {
lab=Y27}
N -1620 550 -1600 550 {
lab=#net33}
N -1700 510 -1540 510 {
lab=VDD}
N -1700 590 -1540 590 {
lab=VSS}
N -1460 550 -1440 550 {
lab=SEL[28]}
N -1770 550 -1760 550 {
lab=Y28}
N -1260 550 -1240 550 {
lab=#net34}
N -1340 510 -1180 510 {
lab=VDD}
N -1340 590 -1180 590 {
lab=VSS}
N -1100 550 -1080 550 {
lab=SEL[29]}
N -1410 550 -1400 550 {
lab=Y29}
N -880 550 -860 550 {
lab=#net35}
N -960 510 -800 510 {
lab=VDD}
N -960 590 -800 590 {
lab=VSS}
N -720 550 -700 550 {
lab=SEL[30]}
N -1030 550 -1020 550 {
lab=Y30}
N -520 550 -500 550 {
lab=#net36}
N -600 510 -440 510 {
lab=VDD}
N -600 590 -440 590 {
lab=VSS}
N -360 550 -340 550 {
lab=SEL[31]}
N -670 550 -660 550 {
lab=Y31}
N -1630 -1990 -1610 -1990 {
lab=#net37}
N -1470 -1990 -1450 -1990 {
lab=CLK_buf}
N -1780 -1990 -1770 -1990 {
lab=CLK}
N -800 -1100 -780 -1100 {
lab=#net38}
N -880 -1140 -720 -1140 {
lab=VDD}
N -880 -1060 -720 -1060 {
lab=VSS}
N -640 -1100 -620 -1100 {
lab=WE[3]}
N -950 -1100 -940 -1100 {
lab=WE3}
N -800 -1220 -780 -1220 {
lab=#net39}
N -880 -1260 -720 -1260 {
lab=VDD}
N -880 -1180 -720 -1180 {
lab=VSS}
N -640 -1220 -620 -1220 {
lab=WE[2]}
N -950 -1220 -940 -1220 {
lab=WE2}
N -800 -1350 -780 -1350 {
lab=#net40}
N -880 -1390 -720 -1390 {
lab=VDD}
N -880 -1310 -720 -1310 {
lab=VSS}
N -640 -1350 -620 -1350 {
lab=WE[1]}
N -950 -1350 -940 -1350 {
lab=WE1}
N -800 -1470 -780 -1470 {
lab=#net41}
N -880 -1510 -720 -1510 {
lab=VDD}
N -880 -1430 -720 -1430 {
lab=VSS}
N -640 -1470 -620 -1470 {
lab=WE[0]}
N -950 -1470 -940 -1470 {
lab=WE0}
N -1620 840 -1600 840 {
lab=#net42}
N -1700 800 -1540 800 {
lab=VDD}
N -1700 880 -1540 880 {
lab=VSS}
N -1460 840 -1440 840 {
lab=Di[0]}
N -1770 840 -1760 840 {
lab=Di<0>}
N -1220 840 -1200 840 {
lab=#net43}
N -1300 800 -1140 800 {
lab=VDD}
N -1300 880 -1140 880 {
lab=VSS}
N -1060 840 -1040 840 {
lab=Di[1]}
N -1370 840 -1360 840 {
lab=Di<1>}
N -1620 970 -1600 970 {
lab=#net44}
N -1700 930 -1540 930 {
lab=VDD}
N -1700 1010 -1540 1010 {
lab=VSS}
N -1460 970 -1440 970 {
lab=Di[4]}
N -1770 970 -1760 970 {
lab=Di<4>}
N -970 840 -960 840 {
lab=Di<2>}
N -820 840 -800 840 {
lab=#net45}
N -570 840 -560 840 {
lab=Di<3>}
N -420 840 -400 840 {
lab=#net46}
N -260 840 -240 840 {
lab=Di[3]}
N -260 970 -240 970 {
lab=Di[7]}
N -420 970 -400 970 {
lab=#net47}
N -570 970 -560 970 {
lab=Di<7>}
N -660 970 -640 970 {
lab=Di[6]}
N -820 970 -800 970 {
lab=#net48}
N -820 930 -740 930 {
lab=VDD}
N -820 1010 -740 1010 {
lab=VSS}
N -900 930 -820 930 {
lab=VDD}
N -900 1010 -820 1010 {
lab=VSS}
N -970 970 -960 970 {
lab=Di<6>}
N -820 840 -800 840 {
lab=#net45}
N -900 800 -740 800 {
lab=VDD}
N -900 880 -740 880 {
lab=VSS}
N -660 840 -640 840 {
lab=Di[2]}
N -970 840 -960 840 {
lab=Di<2>}
N -420 840 -400 840 {
lab=#net46}
N -500 800 -340 800 {
lab=VDD}
N -500 880 -340 880 {
lab=VSS}
N -260 840 -240 840 {
lab=Di[3]}
N -570 840 -560 840 {
lab=Di<3>}
N -420 970 -400 970 {
lab=#net47}
N -500 930 -340 930 {
lab=VDD}
N -500 1010 -340 1010 {
lab=VSS}
N -260 970 -240 970 {
lab=Di[7]}
N -570 970 -560 970 {
lab=Di<7>}
N -1220 970 -1200 970 {
lab=#net49}
N -1300 930 -1140 930 {
lab=VDD}
N -1300 1010 -1140 1010 {
lab=VSS}
N -1060 970 -1040 970 {
lab=Di[5]}
N -1370 970 -1360 970 {
lab=Di<5>}
N -1620 1100 -1600 1100 {
lab=#net50}
N -1700 1060 -1540 1060 {
lab=VDD}
N -1700 1140 -1540 1140 {
lab=VSS}
N -1460 1100 -1440 1100 {
lab=Di[8]}
N -1770 1100 -1760 1100 {
lab=Di<8>}
N -1220 1100 -1200 1100 {
lab=#net51}
N -1300 1060 -1140 1060 {
lab=VDD}
N -1300 1140 -1140 1140 {
lab=VSS}
N -1060 1100 -1040 1100 {
lab=Di[9]}
N -1370 1100 -1360 1100 {
lab=Di<9>}
N -820 1100 -800 1100 {
lab=#net52}
N -900 1060 -740 1060 {
lab=VDD}
N -900 1140 -740 1140 {
lab=VSS}
N -660 1100 -640 1100 {
lab=Di[10]}
N -970 1100 -960 1100 {
lab=Di<10>}
N -420 1100 -400 1100 {
lab=#net53}
N -500 1060 -340 1060 {
lab=VDD}
N -500 1140 -340 1140 {
lab=VSS}
N -260 1100 -240 1100 {
lab=Di[11]}
N -570 1100 -560 1100 {
lab=Di<11>}
N -420 1230 -400 1230 {
lab=#net54}
N -500 1190 -340 1190 {
lab=VDD}
N -500 1270 -340 1270 {
lab=VSS}
N -260 1230 -240 1230 {
lab=Di[15]}
N -570 1230 -560 1230 {
lab=Di<15>}
N -820 1230 -800 1230 {
lab=#net55}
N -900 1190 -740 1190 {
lab=VDD}
N -900 1270 -740 1270 {
lab=VSS}
N -660 1230 -640 1230 {
lab=Di[14]}
N -970 1230 -960 1230 {
lab=Di<14>}
N -1220 1230 -1200 1230 {
lab=#net56}
N -1300 1190 -1140 1190 {
lab=VDD}
N -1300 1270 -1140 1270 {
lab=VSS}
N -1060 1230 -1040 1230 {
lab=Di[13]}
N -1370 1230 -1360 1230 {
lab=Di<13>}
N -1620 1230 -1600 1230 {
lab=#net57}
N -1700 1190 -1540 1190 {
lab=VDD}
N -1700 1270 -1540 1270 {
lab=VSS}
N -1460 1230 -1440 1230 {
lab=Di[12]}
N -1770 1230 -1760 1230 {
lab=Di<12>}
N -1620 1360 -1600 1360 {
lab=#net58}
N -1700 1320 -1540 1320 {
lab=VDD}
N -1700 1400 -1540 1400 {
lab=VSS}
N -1460 1360 -1440 1360 {
lab=Di[16]}
N -1770 1360 -1760 1360 {
lab=Di<16>}
N -1620 1490 -1600 1490 {
lab=#net59}
N -1700 1450 -1540 1450 {
lab=VDD}
N -1700 1530 -1540 1530 {
lab=VSS}
N -1460 1490 -1440 1490 {
lab=Di[20]}
N -1770 1490 -1760 1490 {
lab=Di<20>}
N -1620 1620 -1600 1620 {
lab=#net60}
N -1700 1580 -1540 1580 {
lab=VDD}
N -1700 1660 -1540 1660 {
lab=VSS}
N -1460 1620 -1440 1620 {
lab=Di[24]}
N -1770 1620 -1760 1620 {
lab=Di<24>}
N -1620 1750 -1600 1750 {
lab=#net61}
N -1700 1710 -1540 1710 {
lab=VDD}
N -1700 1790 -1540 1790 {
lab=VSS}
N -1460 1750 -1440 1750 {
lab=Di[28]}
N -1770 1750 -1760 1750 {
lab=Di<28>}
N -1220 1750 -1200 1750 {
lab=#net62}
N -1300 1710 -1140 1710 {
lab=VDD}
N -1300 1790 -1140 1790 {
lab=VSS}
N -1060 1750 -1040 1750 {
lab=Di[29]}
N -1370 1750 -1360 1750 {
lab=Di<29>}
N -1220 1620 -1200 1620 {
lab=#net63}
N -1300 1580 -1140 1580 {
lab=VDD}
N -1300 1660 -1140 1660 {
lab=VSS}
N -1060 1620 -1040 1620 {
lab=Di[25]}
N -1370 1620 -1360 1620 {
lab=Di<25>}
N -1220 1490 -1200 1490 {
lab=#net64}
N -1300 1450 -1140 1450 {
lab=VDD}
N -1300 1530 -1140 1530 {
lab=VSS}
N -1060 1490 -1040 1490 {
lab=Di[21]}
N -1370 1490 -1360 1490 {
lab=Di<21>}
N -1220 1360 -1200 1360 {
lab=#net65}
N -1300 1320 -1140 1320 {
lab=VDD}
N -1300 1400 -1140 1400 {
lab=VSS}
N -1060 1360 -1040 1360 {
lab=Di[17]}
N -1370 1360 -1360 1360 {
lab=Di<17>}
N -820 1360 -800 1360 {
lab=#net66}
N -900 1320 -740 1320 {
lab=VDD}
N -900 1400 -740 1400 {
lab=VSS}
N -660 1360 -640 1360 {
lab=Di[18]}
N -970 1360 -960 1360 {
lab=Di<18>}
N -820 1490 -800 1490 {
lab=#net67}
N -900 1450 -740 1450 {
lab=VDD}
N -900 1530 -740 1530 {
lab=VSS}
N -660 1490 -640 1490 {
lab=Di[22]}
N -970 1490 -960 1490 {
lab=Di<22>}
N -820 1620 -800 1620 {
lab=#net68}
N -900 1580 -740 1580 {
lab=VDD}
N -900 1660 -740 1660 {
lab=VSS}
N -660 1620 -640 1620 {
lab=Di[26]}
N -970 1620 -960 1620 {
lab=Di<26>}
N -820 1750 -800 1750 {
lab=#net69}
N -900 1710 -740 1710 {
lab=VDD}
N -900 1790 -740 1790 {
lab=VSS}
N -660 1750 -640 1750 {
lab=Di[30]}
N -970 1750 -960 1750 {
lab=Di<30>}
N -420 1750 -400 1750 {
lab=#net70}
N -500 1710 -340 1710 {
lab=VDD}
N -500 1790 -340 1790 {
lab=VSS}
N -260 1750 -240 1750 {
lab=Di[31]}
N -570 1750 -560 1750 {
lab=Di<31>}
N -420 1620 -400 1620 {
lab=#net71}
N -500 1580 -340 1580 {
lab=VDD}
N -500 1660 -340 1660 {
lab=VSS}
N -260 1620 -240 1620 {
lab=Di[27]}
N -570 1620 -560 1620 {
lab=Di<27>}
N -420 1490 -400 1490 {
lab=#net72}
N -500 1450 -340 1450 {
lab=VDD}
N -500 1530 -340 1530 {
lab=VSS}
N -260 1490 -240 1490 {
lab=Di[23]}
N -570 1490 -560 1490 {
lab=Di<23>}
N -420 1360 -400 1360 {
lab=#net73}
N -500 1320 -340 1320 {
lab=VDD}
N -500 1400 -340 1400 {
lab=VSS}
N -260 1360 -240 1360 {
lab=Di[19]}
N -570 1360 -560 1360 {
lab=Di<19>}
N -40 -1760 -20 -1760 {
lab=Di[0]}
N -40 -1740 -20 -1740 {
lab=Di[1]}
N -40 -1720 -20 -1720 {
lab=Di[2]}
N -40 -1700 -20 -1700 {
lab=Di[3]}
N -40 -1680 -20 -1680 {
lab=Di[4]}
N -40 -1660 -20 -1660 {
lab=Di[5]}
N -40 -1640 -20 -1640 {
lab=Di[6]}
N -40 -1620 -20 -1620 {
lab=Di[7]}
N -40 -1600 -20 -1600 {
lab=Di[8]}
N -40 -1580 -20 -1580 {
lab=Di[9]}
N -40 -1560 -20 -1560 {
lab=Di[10]}
N -40 -1540 -20 -1540 {
lab=Di[11]}
N -40 -1520 -20 -1520 {
lab=Di[12]}
N -40 -1500 -20 -1500 {
lab=Di[13]}
N -40 -1480 -20 -1480 {
lab=Di[14]}
N -40 -1460 -20 -1460 {
lab=Di[15]}
N -40 -1440 -20 -1440 {
lab=Di[16]}
N -40 -1420 -20 -1420 {
lab=Di[17]}
N -40 -1400 -20 -1400 {
lab=Di[18]}
N -40 -1380 -20 -1380 {
lab=Di[19]}
N -40 -1360 -20 -1360 {
lab=Di[20]}
N -40 -1340 -20 -1340 {
lab=Di[21]}
N -40 -1320 -20 -1320 {
lab=Di[22]}
N -40 -1300 -20 -1300 {
lab=Di[23]}
N -40 -1280 -20 -1280 {
lab=Di[24]}
N -40 -1260 -20 -1260 {
lab=Di[25]}
N -40 -1240 -20 -1240 {
lab=Di[26]}
N -40 -1220 -20 -1220 {
lab=Di[27]}
N -40 -1200 -20 -1200 {
lab=Di[28]}
N -40 -1180 -20 -1180 {
lab=Di[29]}
N -40 -1160 -20 -1160 {
lab=Di[30]}
N -40 -1140 -20 -1140 {
lab=Di[31]}
N 280 -1760 300 -1760 {
lab=Do[0]}
N 280 -1740 300 -1740 {
lab=Do[1]}
N 280 -1720 300 -1720 {
lab=Do[2]}
N 280 -1700 300 -1700 {
lab=Do[3]}
N 280 -1680 300 -1680 {
lab=Do[4]}
N 280 -1660 300 -1660 {
lab=Do[5]}
N 280 -1640 300 -1640 {
lab=Do[6]}
N 280 -1620 300 -1620 {
lab=Do[7]}
N 280 -1600 300 -1600 {
lab=Do[8]}
N 280 -1580 300 -1580 {
lab=Do[9]}
N 280 -1560 300 -1560 {
lab=Do[10]}
N 280 -1540 300 -1540 {
lab=Do[11]}
N 280 -1520 300 -1520 {
lab=Do[12]}
N 280 -1500 300 -1500 {
lab=Do[13]}
N 280 -1480 300 -1480 {
lab=Do[14]}
N 280 -1460 300 -1460 {
lab=Do[15]}
N 280 -1440 300 -1440 {
lab=Do[16]}
N 280 -1420 300 -1420 {
lab=Do[17]}
N 280 -1400 300 -1400 {
lab=Do[18]}
N 280 -1380 300 -1380 {
lab=Do[19]}
N 280 -1360 300 -1360 {
lab=Do[20]}
N 280 -1340 300 -1340 {
lab=Do[21]}
N 280 -1320 300 -1320 {
lab=Do[22]}
N 280 -1300 300 -1300 {
lab=Do[23]}
N 280 -1280 300 -1280 {
lab=Do[24]}
N 280 -1260 300 -1260 {
lab=Do[25]}
N 280 -1240 300 -1240 {
lab=Do[26]}
N 280 -1220 300 -1220 {
lab=Do[27]}
N 280 -1200 300 -1200 {
lab=Do[28]}
N 280 -1180 300 -1180 {
lab=Do[29]}
N 280 -1160 300 -1160 {
lab=Do[30]}
N 280 -1140 300 -1140 {
lab=Do[31]}
N 50 -1820 50 -1800 {
lab=CLK_buf}
N 70 -1820 70 -1800 {
lab=SEL[0]}
N 90 -1820 90 -1800 {
lab=WE[0]}
N 110 -1820 110 -1800 {
lab=WE[1]}
N 130 -1820 130 -1800 {
lab=WE[2]}
N 150 -1820 150 -1800 {
lab=WE[3]}
N 180 -1820 180 -1800 {
lab=VDD}
N 200 -1820 200 -1800 {
lab=VSS}
N 480 -1760 500 -1760 {
lab=Di[0]}
N 480 -1740 500 -1740 {
lab=Di[1]}
N 480 -1720 500 -1720 {
lab=Di[2]}
N 480 -1700 500 -1700 {
lab=Di[3]}
N 480 -1680 500 -1680 {
lab=Di[4]}
N 480 -1660 500 -1660 {
lab=Di[5]}
N 480 -1640 500 -1640 {
lab=Di[6]}
N 480 -1620 500 -1620 {
lab=Di[7]}
N 480 -1600 500 -1600 {
lab=Di[8]}
N 480 -1580 500 -1580 {
lab=Di[9]}
N 480 -1560 500 -1560 {
lab=Di[10]}
N 480 -1540 500 -1540 {
lab=Di[11]}
N 480 -1520 500 -1520 {
lab=Di[12]}
N 480 -1500 500 -1500 {
lab=Di[13]}
N 480 -1480 500 -1480 {
lab=Di[14]}
N 480 -1460 500 -1460 {
lab=Di[15]}
N 480 -1440 500 -1440 {
lab=Di[16]}
N 480 -1420 500 -1420 {
lab=Di[17]}
N 480 -1400 500 -1400 {
lab=Di[18]}
N 480 -1380 500 -1380 {
lab=Di[19]}
N 480 -1360 500 -1360 {
lab=Di[20]}
N 480 -1340 500 -1340 {
lab=Di[21]}
N 480 -1320 500 -1320 {
lab=Di[22]}
N 480 -1300 500 -1300 {
lab=Di[23]}
N 480 -1280 500 -1280 {
lab=Di[24]}
N 480 -1260 500 -1260 {
lab=Di[25]}
N 480 -1240 500 -1240 {
lab=Di[26]}
N 480 -1220 500 -1220 {
lab=Di[27]}
N 480 -1200 500 -1200 {
lab=Di[28]}
N 480 -1180 500 -1180 {
lab=Di[29]}
N 480 -1160 500 -1160 {
lab=Di[30]}
N 480 -1140 500 -1140 {
lab=Di[31]}
N 800 -1760 820 -1760 {
lab=Do[0]}
N 800 -1740 820 -1740 {
lab=Do[1]}
N 800 -1720 820 -1720 {
lab=Do[2]}
N 800 -1700 820 -1700 {
lab=Do[3]}
N 800 -1680 820 -1680 {
lab=Do[4]}
N 800 -1660 820 -1660 {
lab=Do[5]}
N 800 -1640 820 -1640 {
lab=Do[6]}
N 800 -1620 820 -1620 {
lab=Do[7]}
N 800 -1600 820 -1600 {
lab=Do[8]}
N 800 -1580 820 -1580 {
lab=Do[9]}
N 800 -1560 820 -1560 {
lab=Do[10]}
N 800 -1540 820 -1540 {
lab=Do[11]}
N 800 -1520 820 -1520 {
lab=Do[12]}
N 800 -1500 820 -1500 {
lab=Do[13]}
N 800 -1480 820 -1480 {
lab=Do[14]}
N 800 -1460 820 -1460 {
lab=Do[15]}
N 800 -1440 820 -1440 {
lab=Do[16]}
N 800 -1420 820 -1420 {
lab=Do[17]}
N 800 -1400 820 -1400 {
lab=Do[18]}
N 800 -1380 820 -1380 {
lab=Do[19]}
N 800 -1360 820 -1360 {
lab=Do[20]}
N 800 -1340 820 -1340 {
lab=Do[21]}
N 800 -1320 820 -1320 {
lab=Do[22]}
N 800 -1300 820 -1300 {
lab=Do[23]}
N 800 -1280 820 -1280 {
lab=Do[24]}
N 800 -1260 820 -1260 {
lab=Do[25]}
N 800 -1240 820 -1240 {
lab=Do[26]}
N 800 -1220 820 -1220 {
lab=Do[27]}
N 800 -1200 820 -1200 {
lab=Do[28]}
N 800 -1180 820 -1180 {
lab=Do[29]}
N 800 -1160 820 -1160 {
lab=Do[30]}
N 800 -1140 820 -1140 {
lab=Do[31]}
N 570 -1820 570 -1800 {
lab=CLK_buf}
N 590 -1820 590 -1800 {
lab=SEL[1]}
N 610 -1820 610 -1800 {
lab=WE[0]}
N 630 -1820 630 -1800 {
lab=WE[1]}
N 650 -1820 650 -1800 {
lab=WE[2]}
N 670 -1820 670 -1800 {
lab=WE[3]}
N 700 -1820 700 -1800 {
lab=VDD}
N 720 -1820 720 -1800 {
lab=VSS}
N 1020 -1760 1040 -1760 {
lab=Di[0]}
N 1020 -1740 1040 -1740 {
lab=Di[1]}
N 1020 -1720 1040 -1720 {
lab=Di[2]}
N 1020 -1700 1040 -1700 {
lab=Di[3]}
N 1020 -1680 1040 -1680 {
lab=Di[4]}
N 1020 -1660 1040 -1660 {
lab=Di[5]}
N 1020 -1640 1040 -1640 {
lab=Di[6]}
N 1020 -1620 1040 -1620 {
lab=Di[7]}
N 1020 -1600 1040 -1600 {
lab=Di[8]}
N 1020 -1580 1040 -1580 {
lab=Di[9]}
N 1020 -1560 1040 -1560 {
lab=Di[10]}
N 1020 -1540 1040 -1540 {
lab=Di[11]}
N 1020 -1520 1040 -1520 {
lab=Di[12]}
N 1020 -1500 1040 -1500 {
lab=Di[13]}
N 1020 -1480 1040 -1480 {
lab=Di[14]}
N 1020 -1460 1040 -1460 {
lab=Di[15]}
N 1020 -1440 1040 -1440 {
lab=Di[16]}
N 1020 -1420 1040 -1420 {
lab=Di[17]}
N 1020 -1400 1040 -1400 {
lab=Di[18]}
N 1020 -1380 1040 -1380 {
lab=Di[19]}
N 1020 -1360 1040 -1360 {
lab=Di[20]}
N 1020 -1340 1040 -1340 {
lab=Di[21]}
N 1020 -1320 1040 -1320 {
lab=Di[22]}
N 1020 -1300 1040 -1300 {
lab=Di[23]}
N 1020 -1280 1040 -1280 {
lab=Di[24]}
N 1020 -1260 1040 -1260 {
lab=Di[25]}
N 1020 -1240 1040 -1240 {
lab=Di[26]}
N 1020 -1220 1040 -1220 {
lab=Di[27]}
N 1020 -1200 1040 -1200 {
lab=Di[28]}
N 1020 -1180 1040 -1180 {
lab=Di[29]}
N 1020 -1160 1040 -1160 {
lab=Di[30]}
N 1020 -1140 1040 -1140 {
lab=Di[31]}
N 1340 -1760 1360 -1760 {
lab=Do[0]}
N 1340 -1740 1360 -1740 {
lab=Do[1]}
N 1340 -1720 1360 -1720 {
lab=Do[2]}
N 1340 -1700 1360 -1700 {
lab=Do[3]}
N 1340 -1680 1360 -1680 {
lab=Do[4]}
N 1340 -1660 1360 -1660 {
lab=Do[5]}
N 1340 -1640 1360 -1640 {
lab=Do[6]}
N 1340 -1620 1360 -1620 {
lab=Do[7]}
N 1340 -1600 1360 -1600 {
lab=Do[8]}
N 1340 -1580 1360 -1580 {
lab=Do[9]}
N 1340 -1560 1360 -1560 {
lab=Do[10]}
N 1340 -1540 1360 -1540 {
lab=Do[11]}
N 1340 -1520 1360 -1520 {
lab=Do[12]}
N 1340 -1500 1360 -1500 {
lab=Do[13]}
N 1340 -1480 1360 -1480 {
lab=Do[14]}
N 1340 -1460 1360 -1460 {
lab=Do[15]}
N 1340 -1440 1360 -1440 {
lab=Do[16]}
N 1340 -1420 1360 -1420 {
lab=Do[17]}
N 1340 -1400 1360 -1400 {
lab=Do[18]}
N 1340 -1380 1360 -1380 {
lab=Do[19]}
N 1340 -1360 1360 -1360 {
lab=Do[20]}
N 1340 -1340 1360 -1340 {
lab=Do[21]}
N 1340 -1320 1360 -1320 {
lab=Do[22]}
N 1340 -1300 1360 -1300 {
lab=Do[23]}
N 1340 -1280 1360 -1280 {
lab=Do[24]}
N 1340 -1260 1360 -1260 {
lab=Do[25]}
N 1340 -1240 1360 -1240 {
lab=Do[26]}
N 1340 -1220 1360 -1220 {
lab=Do[27]}
N 1340 -1200 1360 -1200 {
lab=Do[28]}
N 1340 -1180 1360 -1180 {
lab=Do[29]}
N 1340 -1160 1360 -1160 {
lab=Do[30]}
N 1340 -1140 1360 -1140 {
lab=Do[31]}
N 1110 -1820 1110 -1800 {
lab=CLK_buf}
N 1130 -1820 1130 -1800 {
lab=SEL[2]}
N 1150 -1820 1150 -1800 {
lab=WE[0]}
N 1170 -1820 1170 -1800 {
lab=WE[1]}
N 1190 -1820 1190 -1800 {
lab=WE[2]}
N 1210 -1820 1210 -1800 {
lab=WE[3]}
N 1240 -1820 1240 -1800 {
lab=VDD}
N 1260 -1820 1260 -1800 {
lab=VSS}
N 1540 -1760 1560 -1760 {
lab=Di[0]}
N 1540 -1740 1560 -1740 {
lab=Di[1]}
N 1540 -1720 1560 -1720 {
lab=Di[2]}
N 1540 -1700 1560 -1700 {
lab=Di[3]}
N 1540 -1680 1560 -1680 {
lab=Di[4]}
N 1540 -1660 1560 -1660 {
lab=Di[5]}
N 1540 -1640 1560 -1640 {
lab=Di[6]}
N 1540 -1620 1560 -1620 {
lab=Di[7]}
N 1540 -1600 1560 -1600 {
lab=Di[8]}
N 1540 -1580 1560 -1580 {
lab=Di[9]}
N 1540 -1560 1560 -1560 {
lab=Di[10]}
N 1540 -1540 1560 -1540 {
lab=Di[11]}
N 1540 -1520 1560 -1520 {
lab=Di[12]}
N 1540 -1500 1560 -1500 {
lab=Di[13]}
N 1540 -1480 1560 -1480 {
lab=Di[14]}
N 1540 -1460 1560 -1460 {
lab=Di[15]}
N 1540 -1440 1560 -1440 {
lab=Di[16]}
N 1540 -1420 1560 -1420 {
lab=Di[17]}
N 1540 -1400 1560 -1400 {
lab=Di[18]}
N 1540 -1380 1560 -1380 {
lab=Di[19]}
N 1540 -1360 1560 -1360 {
lab=Di[20]}
N 1540 -1340 1560 -1340 {
lab=Di[21]}
N 1540 -1320 1560 -1320 {
lab=Di[22]}
N 1540 -1300 1560 -1300 {
lab=Di[23]}
N 1540 -1280 1560 -1280 {
lab=Di[24]}
N 1540 -1260 1560 -1260 {
lab=Di[25]}
N 1540 -1240 1560 -1240 {
lab=Di[26]}
N 1540 -1220 1560 -1220 {
lab=Di[27]}
N 1540 -1200 1560 -1200 {
lab=Di[28]}
N 1540 -1180 1560 -1180 {
lab=Di[29]}
N 1540 -1160 1560 -1160 {
lab=Di[30]}
N 1540 -1140 1560 -1140 {
lab=Di[31]}
N 1860 -1760 1880 -1760 {
lab=Do[0]}
N 1860 -1740 1880 -1740 {
lab=Do[1]}
N 1860 -1720 1880 -1720 {
lab=Do[2]}
N 1860 -1700 1880 -1700 {
lab=Do[3]}
N 1860 -1680 1880 -1680 {
lab=Do[4]}
N 1860 -1660 1880 -1660 {
lab=Do[5]}
N 1860 -1640 1880 -1640 {
lab=Do[6]}
N 1860 -1620 1880 -1620 {
lab=Do[7]}
N 1860 -1600 1880 -1600 {
lab=Do[8]}
N 1860 -1580 1880 -1580 {
lab=Do[9]}
N 1860 -1560 1880 -1560 {
lab=Do[10]}
N 1860 -1540 1880 -1540 {
lab=Do[11]}
N 1860 -1520 1880 -1520 {
lab=Do[12]}
N 1860 -1500 1880 -1500 {
lab=Do[13]}
N 1860 -1480 1880 -1480 {
lab=Do[14]}
N 1860 -1460 1880 -1460 {
lab=Do[15]}
N 1860 -1440 1880 -1440 {
lab=Do[16]}
N 1860 -1420 1880 -1420 {
lab=Do[17]}
N 1860 -1400 1880 -1400 {
lab=Do[18]}
N 1860 -1380 1880 -1380 {
lab=Do[19]}
N 1860 -1360 1880 -1360 {
lab=Do[20]}
N 1860 -1340 1880 -1340 {
lab=Do[21]}
N 1860 -1320 1880 -1320 {
lab=Do[22]}
N 1860 -1300 1880 -1300 {
lab=Do[23]}
N 1860 -1280 1880 -1280 {
lab=Do[24]}
N 1860 -1260 1880 -1260 {
lab=Do[25]}
N 1860 -1240 1880 -1240 {
lab=Do[26]}
N 1860 -1220 1880 -1220 {
lab=Do[27]}
N 1860 -1200 1880 -1200 {
lab=Do[28]}
N 1860 -1180 1880 -1180 {
lab=Do[29]}
N 1860 -1160 1880 -1160 {
lab=Do[30]}
N 1860 -1140 1880 -1140 {
lab=Do[31]}
N 1630 -1820 1630 -1800 {
lab=CLK_buf}
N 1650 -1820 1650 -1800 {
lab=SEL[3]}
N 1670 -1820 1670 -1800 {
lab=WE[0]}
N 1690 -1820 1690 -1800 {
lab=WE[1]}
N 1710 -1820 1710 -1800 {
lab=WE[2]}
N 1730 -1820 1730 -1800 {
lab=WE[3]}
N 1760 -1820 1760 -1800 {
lab=VDD}
N 1780 -1820 1780 -1800 {
lab=VSS}
N 2060 -1760 2080 -1760 {
lab=Di[0]}
N 2060 -1740 2080 -1740 {
lab=Di[1]}
N 2060 -1720 2080 -1720 {
lab=Di[2]}
N 2060 -1700 2080 -1700 {
lab=Di[3]}
N 2060 -1680 2080 -1680 {
lab=Di[4]}
N 2060 -1660 2080 -1660 {
lab=Di[5]}
N 2060 -1640 2080 -1640 {
lab=Di[6]}
N 2060 -1620 2080 -1620 {
lab=Di[7]}
N 2060 -1600 2080 -1600 {
lab=Di[8]}
N 2060 -1580 2080 -1580 {
lab=Di[9]}
N 2060 -1560 2080 -1560 {
lab=Di[10]}
N 2060 -1540 2080 -1540 {
lab=Di[11]}
N 2060 -1520 2080 -1520 {
lab=Di[12]}
N 2060 -1500 2080 -1500 {
lab=Di[13]}
N 2060 -1480 2080 -1480 {
lab=Di[14]}
N 2060 -1460 2080 -1460 {
lab=Di[15]}
N 2060 -1440 2080 -1440 {
lab=Di[16]}
N 2060 -1420 2080 -1420 {
lab=Di[17]}
N 2060 -1400 2080 -1400 {
lab=Di[18]}
N 2060 -1380 2080 -1380 {
lab=Di[19]}
N 2060 -1360 2080 -1360 {
lab=Di[20]}
N 2060 -1340 2080 -1340 {
lab=Di[21]}
N 2060 -1320 2080 -1320 {
lab=Di[22]}
N 2060 -1300 2080 -1300 {
lab=Di[23]}
N 2060 -1280 2080 -1280 {
lab=Di[24]}
N 2060 -1260 2080 -1260 {
lab=Di[25]}
N 2060 -1240 2080 -1240 {
lab=Di[26]}
N 2060 -1220 2080 -1220 {
lab=Di[27]}
N 2060 -1200 2080 -1200 {
lab=Di[28]}
N 2060 -1180 2080 -1180 {
lab=Di[29]}
N 2060 -1160 2080 -1160 {
lab=Di[30]}
N 2060 -1140 2080 -1140 {
lab=Di[31]}
N 2380 -1760 2400 -1760 {
lab=Do[0]}
N 2380 -1740 2400 -1740 {
lab=Do[1]}
N 2380 -1720 2400 -1720 {
lab=Do[2]}
N 2380 -1700 2400 -1700 {
lab=Do[3]}
N 2380 -1680 2400 -1680 {
lab=Do[4]}
N 2380 -1660 2400 -1660 {
lab=Do[5]}
N 2380 -1640 2400 -1640 {
lab=Do[6]}
N 2380 -1620 2400 -1620 {
lab=Do[7]}
N 2380 -1600 2400 -1600 {
lab=Do[8]}
N 2380 -1580 2400 -1580 {
lab=Do[9]}
N 2380 -1560 2400 -1560 {
lab=Do[10]}
N 2380 -1540 2400 -1540 {
lab=Do[11]}
N 2380 -1520 2400 -1520 {
lab=Do[12]}
N 2380 -1500 2400 -1500 {
lab=Do[13]}
N 2380 -1480 2400 -1480 {
lab=Do[14]}
N 2380 -1460 2400 -1460 {
lab=Do[15]}
N 2380 -1440 2400 -1440 {
lab=Do[16]}
N 2380 -1420 2400 -1420 {
lab=Do[17]}
N 2380 -1400 2400 -1400 {
lab=Do[18]}
N 2380 -1380 2400 -1380 {
lab=Do[19]}
N 2380 -1360 2400 -1360 {
lab=Do[20]}
N 2380 -1340 2400 -1340 {
lab=Do[21]}
N 2380 -1320 2400 -1320 {
lab=Do[22]}
N 2380 -1300 2400 -1300 {
lab=Do[23]}
N 2380 -1280 2400 -1280 {
lab=Do[24]}
N 2380 -1260 2400 -1260 {
lab=Do[25]}
N 2380 -1240 2400 -1240 {
lab=Do[26]}
N 2380 -1220 2400 -1220 {
lab=Do[27]}
N 2380 -1200 2400 -1200 {
lab=Do[28]}
N 2380 -1180 2400 -1180 {
lab=Do[29]}
N 2380 -1160 2400 -1160 {
lab=Do[30]}
N 2380 -1140 2400 -1140 {
lab=Do[31]}
N 2150 -1820 2150 -1800 {
lab=CLK_buf}
N 2170 -1820 2170 -1800 {
lab=SEL[4]}
N 2190 -1820 2190 -1800 {
lab=WE[0]}
N 2210 -1820 2210 -1800 {
lab=WE[1]}
N 2230 -1820 2230 -1800 {
lab=WE[2]}
N 2250 -1820 2250 -1800 {
lab=WE[3]}
N 2280 -1820 2280 -1800 {
lab=VDD}
N 2300 -1820 2300 -1800 {
lab=VSS}
N 2580 -1760 2600 -1760 {
lab=Di[0]}
N 2580 -1740 2600 -1740 {
lab=Di[1]}
N 2580 -1720 2600 -1720 {
lab=Di[2]}
N 2580 -1700 2600 -1700 {
lab=Di[3]}
N 2580 -1680 2600 -1680 {
lab=Di[4]}
N 2580 -1660 2600 -1660 {
lab=Di[5]}
N 2580 -1640 2600 -1640 {
lab=Di[6]}
N 2580 -1620 2600 -1620 {
lab=Di[7]}
N 2580 -1600 2600 -1600 {
lab=Di[8]}
N 2580 -1580 2600 -1580 {
lab=Di[9]}
N 2580 -1560 2600 -1560 {
lab=Di[10]}
N 2580 -1540 2600 -1540 {
lab=Di[11]}
N 2580 -1520 2600 -1520 {
lab=Di[12]}
N 2580 -1500 2600 -1500 {
lab=Di[13]}
N 2580 -1480 2600 -1480 {
lab=Di[14]}
N 2580 -1460 2600 -1460 {
lab=Di[15]}
N 2580 -1440 2600 -1440 {
lab=Di[16]}
N 2580 -1420 2600 -1420 {
lab=Di[17]}
N 2580 -1400 2600 -1400 {
lab=Di[18]}
N 2580 -1380 2600 -1380 {
lab=Di[19]}
N 2580 -1360 2600 -1360 {
lab=Di[20]}
N 2580 -1340 2600 -1340 {
lab=Di[21]}
N 2580 -1320 2600 -1320 {
lab=Di[22]}
N 2580 -1300 2600 -1300 {
lab=Di[23]}
N 2580 -1280 2600 -1280 {
lab=Di[24]}
N 2580 -1260 2600 -1260 {
lab=Di[25]}
N 2580 -1240 2600 -1240 {
lab=Di[26]}
N 2580 -1220 2600 -1220 {
lab=Di[27]}
N 2580 -1200 2600 -1200 {
lab=Di[28]}
N 2580 -1180 2600 -1180 {
lab=Di[29]}
N 2580 -1160 2600 -1160 {
lab=Di[30]}
N 2580 -1140 2600 -1140 {
lab=Di[31]}
N 2900 -1760 2920 -1760 {
lab=Do[0]}
N 2900 -1740 2920 -1740 {
lab=Do[1]}
N 2900 -1720 2920 -1720 {
lab=Do[2]}
N 2900 -1700 2920 -1700 {
lab=Do[3]}
N 2900 -1680 2920 -1680 {
lab=Do[4]}
N 2900 -1660 2920 -1660 {
lab=Do[5]}
N 2900 -1640 2920 -1640 {
lab=Do[6]}
N 2900 -1620 2920 -1620 {
lab=Do[7]}
N 2900 -1600 2920 -1600 {
lab=Do[8]}
N 2900 -1580 2920 -1580 {
lab=Do[9]}
N 2900 -1560 2920 -1560 {
lab=Do[10]}
N 2900 -1540 2920 -1540 {
lab=Do[11]}
N 2900 -1520 2920 -1520 {
lab=Do[12]}
N 2900 -1500 2920 -1500 {
lab=Do[13]}
N 2900 -1480 2920 -1480 {
lab=Do[14]}
N 2900 -1460 2920 -1460 {
lab=Do[15]}
N 2900 -1440 2920 -1440 {
lab=Do[16]}
N 2900 -1420 2920 -1420 {
lab=Do[17]}
N 2900 -1400 2920 -1400 {
lab=Do[18]}
N 2900 -1380 2920 -1380 {
lab=Do[19]}
N 2900 -1360 2920 -1360 {
lab=Do[20]}
N 2900 -1340 2920 -1340 {
lab=Do[21]}
N 2900 -1320 2920 -1320 {
lab=Do[22]}
N 2900 -1300 2920 -1300 {
lab=Do[23]}
N 2900 -1280 2920 -1280 {
lab=Do[24]}
N 2900 -1260 2920 -1260 {
lab=Do[25]}
N 2900 -1240 2920 -1240 {
lab=Do[26]}
N 2900 -1220 2920 -1220 {
lab=Do[27]}
N 2900 -1200 2920 -1200 {
lab=Do[28]}
N 2900 -1180 2920 -1180 {
lab=Do[29]}
N 2900 -1160 2920 -1160 {
lab=Do[30]}
N 2900 -1140 2920 -1140 {
lab=Do[31]}
N 2670 -1820 2670 -1800 {
lab=CLK_buf}
N 2690 -1820 2690 -1800 {
lab=SEL[5]}
N 2710 -1820 2710 -1800 {
lab=WE[0]}
N 2730 -1820 2730 -1800 {
lab=WE[1]}
N 2750 -1820 2750 -1800 {
lab=WE[2]}
N 2770 -1820 2770 -1800 {
lab=WE[3]}
N 2800 -1820 2800 -1800 {
lab=VDD}
N 2820 -1820 2820 -1800 {
lab=VSS}
N 3120 -1760 3140 -1760 {
lab=Di[0]}
N 3120 -1740 3140 -1740 {
lab=Di[1]}
N 3120 -1720 3140 -1720 {
lab=Di[2]}
N 3120 -1700 3140 -1700 {
lab=Di[3]}
N 3120 -1680 3140 -1680 {
lab=Di[4]}
N 3120 -1660 3140 -1660 {
lab=Di[5]}
N 3120 -1640 3140 -1640 {
lab=Di[6]}
N 3120 -1620 3140 -1620 {
lab=Di[7]}
N 3120 -1600 3140 -1600 {
lab=Di[8]}
N 3120 -1580 3140 -1580 {
lab=Di[9]}
N 3120 -1560 3140 -1560 {
lab=Di[10]}
N 3120 -1540 3140 -1540 {
lab=Di[11]}
N 3120 -1520 3140 -1520 {
lab=Di[12]}
N 3120 -1500 3140 -1500 {
lab=Di[13]}
N 3120 -1480 3140 -1480 {
lab=Di[14]}
N 3120 -1460 3140 -1460 {
lab=Di[15]}
N 3120 -1440 3140 -1440 {
lab=Di[16]}
N 3120 -1420 3140 -1420 {
lab=Di[17]}
N 3120 -1400 3140 -1400 {
lab=Di[18]}
N 3120 -1380 3140 -1380 {
lab=Di[19]}
N 3120 -1360 3140 -1360 {
lab=Di[20]}
N 3120 -1340 3140 -1340 {
lab=Di[21]}
N 3120 -1320 3140 -1320 {
lab=Di[22]}
N 3120 -1300 3140 -1300 {
lab=Di[23]}
N 3120 -1280 3140 -1280 {
lab=Di[24]}
N 3120 -1260 3140 -1260 {
lab=Di[25]}
N 3120 -1240 3140 -1240 {
lab=Di[26]}
N 3120 -1220 3140 -1220 {
lab=Di[27]}
N 3120 -1200 3140 -1200 {
lab=Di[28]}
N 3120 -1180 3140 -1180 {
lab=Di[29]}
N 3120 -1160 3140 -1160 {
lab=Di[30]}
N 3120 -1140 3140 -1140 {
lab=Di[31]}
N 3440 -1760 3460 -1760 {
lab=Do[0]}
N 3440 -1740 3460 -1740 {
lab=Do[1]}
N 3440 -1720 3460 -1720 {
lab=Do[2]}
N 3440 -1700 3460 -1700 {
lab=Do[3]}
N 3440 -1680 3460 -1680 {
lab=Do[4]}
N 3440 -1660 3460 -1660 {
lab=Do[5]}
N 3440 -1640 3460 -1640 {
lab=Do[6]}
N 3440 -1620 3460 -1620 {
lab=Do[7]}
N 3440 -1600 3460 -1600 {
lab=Do[8]}
N 3440 -1580 3460 -1580 {
lab=Do[9]}
N 3440 -1560 3460 -1560 {
lab=Do[10]}
N 3440 -1540 3460 -1540 {
lab=Do[11]}
N 3440 -1520 3460 -1520 {
lab=Do[12]}
N 3440 -1500 3460 -1500 {
lab=Do[13]}
N 3440 -1480 3460 -1480 {
lab=Do[14]}
N 3440 -1460 3460 -1460 {
lab=Do[15]}
N 3440 -1440 3460 -1440 {
lab=Do[16]}
N 3440 -1420 3460 -1420 {
lab=Do[17]}
N 3440 -1400 3460 -1400 {
lab=Do[18]}
N 3440 -1380 3460 -1380 {
lab=Do[19]}
N 3440 -1360 3460 -1360 {
lab=Do[20]}
N 3440 -1340 3460 -1340 {
lab=Do[21]}
N 3440 -1320 3460 -1320 {
lab=Do[22]}
N 3440 -1300 3460 -1300 {
lab=Do[23]}
N 3440 -1280 3460 -1280 {
lab=Do[24]}
N 3440 -1260 3460 -1260 {
lab=Do[25]}
N 3440 -1240 3460 -1240 {
lab=Do[26]}
N 3440 -1220 3460 -1220 {
lab=Do[27]}
N 3440 -1200 3460 -1200 {
lab=Do[28]}
N 3440 -1180 3460 -1180 {
lab=Do[29]}
N 3440 -1160 3460 -1160 {
lab=Do[30]}
N 3440 -1140 3460 -1140 {
lab=Do[31]}
N 3210 -1820 3210 -1800 {
lab=CLK_buf}
N 3230 -1820 3230 -1800 {
lab=SEL[6]}
N 3250 -1820 3250 -1800 {
lab=WE[0]}
N 3270 -1820 3270 -1800 {
lab=WE[1]}
N 3290 -1820 3290 -1800 {
lab=WE[2]}
N 3310 -1820 3310 -1800 {
lab=WE[3]}
N 3340 -1820 3340 -1800 {
lab=VDD}
N 3360 -1820 3360 -1800 {
lab=VSS}
N 3640 -1760 3660 -1760 {
lab=Di[0]}
N 3640 -1740 3660 -1740 {
lab=Di[1]}
N 3640 -1720 3660 -1720 {
lab=Di[2]}
N 3640 -1700 3660 -1700 {
lab=Di[3]}
N 3640 -1680 3660 -1680 {
lab=Di[4]}
N 3640 -1660 3660 -1660 {
lab=Di[5]}
N 3640 -1640 3660 -1640 {
lab=Di[6]}
N 3640 -1620 3660 -1620 {
lab=Di[7]}
N 3640 -1600 3660 -1600 {
lab=Di[8]}
N 3640 -1580 3660 -1580 {
lab=Di[9]}
N 3640 -1560 3660 -1560 {
lab=Di[10]}
N 3640 -1540 3660 -1540 {
lab=Di[11]}
N 3640 -1520 3660 -1520 {
lab=Di[12]}
N 3640 -1500 3660 -1500 {
lab=Di[13]}
N 3640 -1480 3660 -1480 {
lab=Di[14]}
N 3640 -1460 3660 -1460 {
lab=Di[15]}
N 3640 -1440 3660 -1440 {
lab=Di[16]}
N 3640 -1420 3660 -1420 {
lab=Di[17]}
N 3640 -1400 3660 -1400 {
lab=Di[18]}
N 3640 -1380 3660 -1380 {
lab=Di[19]}
N 3640 -1360 3660 -1360 {
lab=Di[20]}
N 3640 -1340 3660 -1340 {
lab=Di[21]}
N 3640 -1320 3660 -1320 {
lab=Di[22]}
N 3640 -1300 3660 -1300 {
lab=Di[23]}
N 3640 -1280 3660 -1280 {
lab=Di[24]}
N 3640 -1260 3660 -1260 {
lab=Di[25]}
N 3640 -1240 3660 -1240 {
lab=Di[26]}
N 3640 -1220 3660 -1220 {
lab=Di[27]}
N 3640 -1200 3660 -1200 {
lab=Di[28]}
N 3640 -1180 3660 -1180 {
lab=Di[29]}
N 3640 -1160 3660 -1160 {
lab=Di[30]}
N 3640 -1140 3660 -1140 {
lab=Di[31]}
N 3960 -1760 3980 -1760 {
lab=Do[0]}
N 3960 -1740 3980 -1740 {
lab=Do[1]}
N 3960 -1720 3980 -1720 {
lab=Do[2]}
N 3960 -1700 3980 -1700 {
lab=Do[3]}
N 3960 -1680 3980 -1680 {
lab=Do[4]}
N 3960 -1660 3980 -1660 {
lab=Do[5]}
N 3960 -1640 3980 -1640 {
lab=Do[6]}
N 3960 -1620 3980 -1620 {
lab=Do[7]}
N 3960 -1600 3980 -1600 {
lab=Do[8]}
N 3960 -1580 3980 -1580 {
lab=Do[9]}
N 3960 -1560 3980 -1560 {
lab=Do[10]}
N 3960 -1540 3980 -1540 {
lab=Do[11]}
N 3960 -1520 3980 -1520 {
lab=Do[12]}
N 3960 -1500 3980 -1500 {
lab=Do[13]}
N 3960 -1480 3980 -1480 {
lab=Do[14]}
N 3960 -1460 3980 -1460 {
lab=Do[15]}
N 3960 -1440 3980 -1440 {
lab=Do[16]}
N 3960 -1420 3980 -1420 {
lab=Do[17]}
N 3960 -1400 3980 -1400 {
lab=Do[18]}
N 3960 -1380 3980 -1380 {
lab=Do[19]}
N 3960 -1360 3980 -1360 {
lab=Do[20]}
N 3960 -1340 3980 -1340 {
lab=Do[21]}
N 3960 -1320 3980 -1320 {
lab=Do[22]}
N 3960 -1300 3980 -1300 {
lab=Do[23]}
N 3960 -1280 3980 -1280 {
lab=Do[24]}
N 3960 -1260 3980 -1260 {
lab=Do[25]}
N 3960 -1240 3980 -1240 {
lab=Do[26]}
N 3960 -1220 3980 -1220 {
lab=Do[27]}
N 3960 -1200 3980 -1200 {
lab=Do[28]}
N 3960 -1180 3980 -1180 {
lab=Do[29]}
N 3960 -1160 3980 -1160 {
lab=Do[30]}
N 3960 -1140 3980 -1140 {
lab=Do[31]}
N 3730 -1820 3730 -1800 {
lab=CLK_buf}
N 3750 -1820 3750 -1800 {
lab=SEL[7]}
N 3770 -1820 3770 -1800 {
lab=WE[0]}
N 3790 -1820 3790 -1800 {
lab=WE[1]}
N 3810 -1820 3810 -1800 {
lab=WE[2]}
N 3830 -1820 3830 -1800 {
lab=WE[3]}
N 3860 -1820 3860 -1800 {
lab=VDD}
N 3880 -1820 3880 -1800 {
lab=VSS}
N 3640 -860 3660 -860 {
lab=Di[0]}
N 3640 -840 3660 -840 {
lab=Di[1]}
N 3640 -820 3660 -820 {
lab=Di[2]}
N 3640 -800 3660 -800 {
lab=Di[3]}
N 3640 -780 3660 -780 {
lab=Di[4]}
N 3640 -760 3660 -760 {
lab=Di[5]}
N 3640 -740 3660 -740 {
lab=Di[6]}
N 3640 -720 3660 -720 {
lab=Di[7]}
N 3640 -700 3660 -700 {
lab=Di[8]}
N 3640 -680 3660 -680 {
lab=Di[9]}
N 3640 -660 3660 -660 {
lab=Di[10]}
N 3640 -640 3660 -640 {
lab=Di[11]}
N 3640 -620 3660 -620 {
lab=Di[12]}
N 3640 -600 3660 -600 {
lab=Di[13]}
N 3640 -580 3660 -580 {
lab=Di[14]}
N 3640 -560 3660 -560 {
lab=Di[15]}
N 3640 -540 3660 -540 {
lab=Di[16]}
N 3640 -520 3660 -520 {
lab=Di[17]}
N 3640 -500 3660 -500 {
lab=Di[18]}
N 3640 -480 3660 -480 {
lab=Di[19]}
N 3640 -460 3660 -460 {
lab=Di[20]}
N 3640 -440 3660 -440 {
lab=Di[21]}
N 3640 -420 3660 -420 {
lab=Di[22]}
N 3640 -400 3660 -400 {
lab=Di[23]}
N 3640 -380 3660 -380 {
lab=Di[24]}
N 3640 -360 3660 -360 {
lab=Di[25]}
N 3640 -340 3660 -340 {
lab=Di[26]}
N 3640 -320 3660 -320 {
lab=Di[27]}
N 3640 -300 3660 -300 {
lab=Di[28]}
N 3640 -280 3660 -280 {
lab=Di[29]}
N 3640 -260 3660 -260 {
lab=Di[30]}
N 3640 -240 3660 -240 {
lab=Di[31]}
N 3960 -860 3980 -860 {
lab=Do[0]}
N 3960 -840 3980 -840 {
lab=Do[1]}
N 3960 -820 3980 -820 {
lab=Do[2]}
N 3960 -800 3980 -800 {
lab=Do[3]}
N 3960 -780 3980 -780 {
lab=Do[4]}
N 3960 -760 3980 -760 {
lab=Do[5]}
N 3960 -740 3980 -740 {
lab=Do[6]}
N 3960 -720 3980 -720 {
lab=Do[7]}
N 3960 -700 3980 -700 {
lab=Do[8]}
N 3960 -680 3980 -680 {
lab=Do[9]}
N 3960 -660 3980 -660 {
lab=Do[10]}
N 3960 -640 3980 -640 {
lab=Do[11]}
N 3960 -620 3980 -620 {
lab=Do[12]}
N 3960 -600 3980 -600 {
lab=Do[13]}
N 3960 -580 3980 -580 {
lab=Do[14]}
N 3960 -560 3980 -560 {
lab=Do[15]}
N 3960 -540 3980 -540 {
lab=Do[16]}
N 3960 -520 3980 -520 {
lab=Do[17]}
N 3960 -500 3980 -500 {
lab=Do[18]}
N 3960 -480 3980 -480 {
lab=Do[19]}
N 3960 -460 3980 -460 {
lab=Do[20]}
N 3960 -440 3980 -440 {
lab=Do[21]}
N 3960 -420 3980 -420 {
lab=Do[22]}
N 3960 -400 3980 -400 {
lab=Do[23]}
N 3960 -380 3980 -380 {
lab=Do[24]}
N 3960 -360 3980 -360 {
lab=Do[25]}
N 3960 -340 3980 -340 {
lab=Do[26]}
N 3960 -320 3980 -320 {
lab=Do[27]}
N 3960 -300 3980 -300 {
lab=Do[28]}
N 3960 -280 3980 -280 {
lab=Do[29]}
N 3960 -260 3980 -260 {
lab=Do[30]}
N 3960 -240 3980 -240 {
lab=Do[31]}
N 3730 -920 3730 -900 {
lab=CLK_buf}
N 3750 -920 3750 -900 {
lab=SEL[15]}
N 3770 -920 3770 -900 {
lab=WE[0]}
N 3790 -920 3790 -900 {
lab=WE[1]}
N 3810 -920 3810 -900 {
lab=WE[2]}
N 3830 -920 3830 -900 {
lab=WE[3]}
N 3860 -920 3860 -900 {
lab=VDD}
N 3880 -920 3880 -900 {
lab=VSS}
N 3120 -860 3140 -860 {
lab=Di[0]}
N 3120 -840 3140 -840 {
lab=Di[1]}
N 3120 -820 3140 -820 {
lab=Di[2]}
N 3120 -800 3140 -800 {
lab=Di[3]}
N 3120 -780 3140 -780 {
lab=Di[4]}
N 3120 -760 3140 -760 {
lab=Di[5]}
N 3120 -740 3140 -740 {
lab=Di[6]}
N 3120 -720 3140 -720 {
lab=Di[7]}
N 3120 -700 3140 -700 {
lab=Di[8]}
N 3120 -680 3140 -680 {
lab=Di[9]}
N 3120 -660 3140 -660 {
lab=Di[10]}
N 3120 -640 3140 -640 {
lab=Di[11]}
N 3120 -620 3140 -620 {
lab=Di[12]}
N 3120 -600 3140 -600 {
lab=Di[13]}
N 3120 -580 3140 -580 {
lab=Di[14]}
N 3120 -560 3140 -560 {
lab=Di[15]}
N 3120 -540 3140 -540 {
lab=Di[16]}
N 3120 -520 3140 -520 {
lab=Di[17]}
N 3120 -500 3140 -500 {
lab=Di[18]}
N 3120 -480 3140 -480 {
lab=Di[19]}
N 3120 -460 3140 -460 {
lab=Di[20]}
N 3120 -440 3140 -440 {
lab=Di[21]}
N 3120 -420 3140 -420 {
lab=Di[22]}
N 3120 -400 3140 -400 {
lab=Di[23]}
N 3120 -380 3140 -380 {
lab=Di[24]}
N 3120 -360 3140 -360 {
lab=Di[25]}
N 3120 -340 3140 -340 {
lab=Di[26]}
N 3120 -320 3140 -320 {
lab=Di[27]}
N 3120 -300 3140 -300 {
lab=Di[28]}
N 3120 -280 3140 -280 {
lab=Di[29]}
N 3120 -260 3140 -260 {
lab=Di[30]}
N 3120 -240 3140 -240 {
lab=Di[31]}
N 3440 -860 3460 -860 {
lab=Do[0]}
N 3440 -840 3460 -840 {
lab=Do[1]}
N 3440 -820 3460 -820 {
lab=Do[2]}
N 3440 -800 3460 -800 {
lab=Do[3]}
N 3440 -780 3460 -780 {
lab=Do[4]}
N 3440 -760 3460 -760 {
lab=Do[5]}
N 3440 -740 3460 -740 {
lab=Do[6]}
N 3440 -720 3460 -720 {
lab=Do[7]}
N 3440 -700 3460 -700 {
lab=Do[8]}
N 3440 -680 3460 -680 {
lab=Do[9]}
N 3440 -660 3460 -660 {
lab=Do[10]}
N 3440 -640 3460 -640 {
lab=Do[11]}
N 3440 -620 3460 -620 {
lab=Do[12]}
N 3440 -600 3460 -600 {
lab=Do[13]}
N 3440 -580 3460 -580 {
lab=Do[14]}
N 3440 -560 3460 -560 {
lab=Do[15]}
N 3440 -540 3460 -540 {
lab=Do[16]}
N 3440 -520 3460 -520 {
lab=Do[17]}
N 3440 -500 3460 -500 {
lab=Do[18]}
N 3440 -480 3460 -480 {
lab=Do[19]}
N 3440 -460 3460 -460 {
lab=Do[20]}
N 3440 -440 3460 -440 {
lab=Do[21]}
N 3440 -420 3460 -420 {
lab=Do[22]}
N 3440 -400 3460 -400 {
lab=Do[23]}
N 3440 -380 3460 -380 {
lab=Do[24]}
N 3440 -360 3460 -360 {
lab=Do[25]}
N 3440 -340 3460 -340 {
lab=Do[26]}
N 3440 -320 3460 -320 {
lab=Do[27]}
N 3440 -300 3460 -300 {
lab=Do[28]}
N 3440 -280 3460 -280 {
lab=Do[29]}
N 3440 -260 3460 -260 {
lab=Do[30]}
N 3440 -240 3460 -240 {
lab=Do[31]}
N 3210 -920 3210 -900 {
lab=CLK_buf}
N 3230 -920 3230 -900 {
lab=SEL[14]}
N 3250 -920 3250 -900 {
lab=WE[0]}
N 3270 -920 3270 -900 {
lab=WE[1]}
N 3290 -920 3290 -900 {
lab=WE[2]}
N 3310 -920 3310 -900 {
lab=WE[3]}
N 3340 -920 3340 -900 {
lab=VDD}
N 3360 -920 3360 -900 {
lab=VSS}
N 2580 -860 2600 -860 {
lab=Di[0]}
N 2580 -840 2600 -840 {
lab=Di[1]}
N 2580 -820 2600 -820 {
lab=Di[2]}
N 2580 -800 2600 -800 {
lab=Di[3]}
N 2580 -780 2600 -780 {
lab=Di[4]}
N 2580 -760 2600 -760 {
lab=Di[5]}
N 2580 -740 2600 -740 {
lab=Di[6]}
N 2580 -720 2600 -720 {
lab=Di[7]}
N 2580 -700 2600 -700 {
lab=Di[8]}
N 2580 -680 2600 -680 {
lab=Di[9]}
N 2580 -660 2600 -660 {
lab=Di[10]}
N 2580 -640 2600 -640 {
lab=Di[11]}
N 2580 -620 2600 -620 {
lab=Di[12]}
N 2580 -600 2600 -600 {
lab=Di[13]}
N 2580 -580 2600 -580 {
lab=Di[14]}
N 2580 -560 2600 -560 {
lab=Di[15]}
N 2580 -540 2600 -540 {
lab=Di[16]}
N 2580 -520 2600 -520 {
lab=Di[17]}
N 2580 -500 2600 -500 {
lab=Di[18]}
N 2580 -480 2600 -480 {
lab=Di[19]}
N 2580 -460 2600 -460 {
lab=Di[20]}
N 2580 -440 2600 -440 {
lab=Di[21]}
N 2580 -420 2600 -420 {
lab=Di[22]}
N 2580 -400 2600 -400 {
lab=Di[23]}
N 2580 -380 2600 -380 {
lab=Di[24]}
N 2580 -360 2600 -360 {
lab=Di[25]}
N 2580 -340 2600 -340 {
lab=Di[26]}
N 2580 -320 2600 -320 {
lab=Di[27]}
N 2580 -300 2600 -300 {
lab=Di[28]}
N 2580 -280 2600 -280 {
lab=Di[29]}
N 2580 -260 2600 -260 {
lab=Di[30]}
N 2580 -240 2600 -240 {
lab=Di[31]}
N 2900 -860 2920 -860 {
lab=Do[0]}
N 2900 -840 2920 -840 {
lab=Do[1]}
N 2900 -820 2920 -820 {
lab=Do[2]}
N 2900 -800 2920 -800 {
lab=Do[3]}
N 2900 -780 2920 -780 {
lab=Do[4]}
N 2900 -760 2920 -760 {
lab=Do[5]}
N 2900 -740 2920 -740 {
lab=Do[6]}
N 2900 -720 2920 -720 {
lab=Do[7]}
N 2900 -700 2920 -700 {
lab=Do[8]}
N 2900 -680 2920 -680 {
lab=Do[9]}
N 2900 -660 2920 -660 {
lab=Do[10]}
N 2900 -640 2920 -640 {
lab=Do[11]}
N 2900 -620 2920 -620 {
lab=Do[12]}
N 2900 -600 2920 -600 {
lab=Do[13]}
N 2900 -580 2920 -580 {
lab=Do[14]}
N 2900 -560 2920 -560 {
lab=Do[15]}
N 2900 -540 2920 -540 {
lab=Do[16]}
N 2900 -520 2920 -520 {
lab=Do[17]}
N 2900 -500 2920 -500 {
lab=Do[18]}
N 2900 -480 2920 -480 {
lab=Do[19]}
N 2900 -460 2920 -460 {
lab=Do[20]}
N 2900 -440 2920 -440 {
lab=Do[21]}
N 2900 -420 2920 -420 {
lab=Do[22]}
N 2900 -400 2920 -400 {
lab=Do[23]}
N 2900 -380 2920 -380 {
lab=Do[24]}
N 2900 -360 2920 -360 {
lab=Do[25]}
N 2900 -340 2920 -340 {
lab=Do[26]}
N 2900 -320 2920 -320 {
lab=Do[27]}
N 2900 -300 2920 -300 {
lab=Do[28]}
N 2900 -280 2920 -280 {
lab=Do[29]}
N 2900 -260 2920 -260 {
lab=Do[30]}
N 2900 -240 2920 -240 {
lab=Do[31]}
N 2670 -920 2670 -900 {
lab=CLK_buf}
N 2690 -920 2690 -900 {
lab=SEL[13]}
N 2710 -920 2710 -900 {
lab=WE[0]}
N 2730 -920 2730 -900 {
lab=WE[1]}
N 2750 -920 2750 -900 {
lab=WE[2]}
N 2770 -920 2770 -900 {
lab=WE[3]}
N 2800 -920 2800 -900 {
lab=VDD}
N 2820 -920 2820 -900 {
lab=VSS}
N 2060 -860 2080 -860 {
lab=Di[0]}
N 2060 -840 2080 -840 {
lab=Di[1]}
N 2060 -820 2080 -820 {
lab=Di[2]}
N 2060 -800 2080 -800 {
lab=Di[3]}
N 2060 -780 2080 -780 {
lab=Di[4]}
N 2060 -760 2080 -760 {
lab=Di[5]}
N 2060 -740 2080 -740 {
lab=Di[6]}
N 2060 -720 2080 -720 {
lab=Di[7]}
N 2060 -700 2080 -700 {
lab=Di[8]}
N 2060 -680 2080 -680 {
lab=Di[9]}
N 2060 -660 2080 -660 {
lab=Di[10]}
N 2060 -640 2080 -640 {
lab=Di[11]}
N 2060 -620 2080 -620 {
lab=Di[12]}
N 2060 -600 2080 -600 {
lab=Di[13]}
N 2060 -580 2080 -580 {
lab=Di[14]}
N 2060 -560 2080 -560 {
lab=Di[15]}
N 2060 -540 2080 -540 {
lab=Di[16]}
N 2060 -520 2080 -520 {
lab=Di[17]}
N 2060 -500 2080 -500 {
lab=Di[18]}
N 2060 -480 2080 -480 {
lab=Di[19]}
N 2060 -460 2080 -460 {
lab=Di[20]}
N 2060 -440 2080 -440 {
lab=Di[21]}
N 2060 -420 2080 -420 {
lab=Di[22]}
N 2060 -400 2080 -400 {
lab=Di[23]}
N 2060 -380 2080 -380 {
lab=Di[24]}
N 2060 -360 2080 -360 {
lab=Di[25]}
N 2060 -340 2080 -340 {
lab=Di[26]}
N 2060 -320 2080 -320 {
lab=Di[27]}
N 2060 -300 2080 -300 {
lab=Di[28]}
N 2060 -280 2080 -280 {
lab=Di[29]}
N 2060 -260 2080 -260 {
lab=Di[30]}
N 2060 -240 2080 -240 {
lab=Di[31]}
N 2380 -860 2400 -860 {
lab=Do[0]}
N 2380 -840 2400 -840 {
lab=Do[1]}
N 2380 -820 2400 -820 {
lab=Do[2]}
N 2380 -800 2400 -800 {
lab=Do[3]}
N 2380 -780 2400 -780 {
lab=Do[4]}
N 2380 -760 2400 -760 {
lab=Do[5]}
N 2380 -740 2400 -740 {
lab=Do[6]}
N 2380 -720 2400 -720 {
lab=Do[7]}
N 2380 -700 2400 -700 {
lab=Do[8]}
N 2380 -680 2400 -680 {
lab=Do[9]}
N 2380 -660 2400 -660 {
lab=Do[10]}
N 2380 -640 2400 -640 {
lab=Do[11]}
N 2380 -620 2400 -620 {
lab=Do[12]}
N 2380 -600 2400 -600 {
lab=Do[13]}
N 2380 -580 2400 -580 {
lab=Do[14]}
N 2380 -560 2400 -560 {
lab=Do[15]}
N 2380 -540 2400 -540 {
lab=Do[16]}
N 2380 -520 2400 -520 {
lab=Do[17]}
N 2380 -500 2400 -500 {
lab=Do[18]}
N 2380 -480 2400 -480 {
lab=Do[19]}
N 2380 -460 2400 -460 {
lab=Do[20]}
N 2380 -440 2400 -440 {
lab=Do[21]}
N 2380 -420 2400 -420 {
lab=Do[22]}
N 2380 -400 2400 -400 {
lab=Do[23]}
N 2380 -380 2400 -380 {
lab=Do[24]}
N 2380 -360 2400 -360 {
lab=Do[25]}
N 2380 -340 2400 -340 {
lab=Do[26]}
N 2380 -320 2400 -320 {
lab=Do[27]}
N 2380 -300 2400 -300 {
lab=Do[28]}
N 2380 -280 2400 -280 {
lab=Do[29]}
N 2380 -260 2400 -260 {
lab=Do[30]}
N 2380 -240 2400 -240 {
lab=Do[31]}
N 2150 -920 2150 -900 {
lab=CLK_buf}
N 2170 -920 2170 -900 {
lab=SEL[12]}
N 2190 -920 2190 -900 {
lab=WE[0]}
N 2210 -920 2210 -900 {
lab=WE[1]}
N 2230 -920 2230 -900 {
lab=WE[2]}
N 2250 -920 2250 -900 {
lab=WE[3]}
N 2280 -920 2280 -900 {
lab=VDD}
N 2300 -920 2300 -900 {
lab=VSS}
N 1540 -860 1560 -860 {
lab=Di[0]}
N 1540 -840 1560 -840 {
lab=Di[1]}
N 1540 -820 1560 -820 {
lab=Di[2]}
N 1540 -800 1560 -800 {
lab=Di[3]}
N 1540 -780 1560 -780 {
lab=Di[4]}
N 1540 -760 1560 -760 {
lab=Di[5]}
N 1540 -740 1560 -740 {
lab=Di[6]}
N 1540 -720 1560 -720 {
lab=Di[7]}
N 1540 -700 1560 -700 {
lab=Di[8]}
N 1540 -680 1560 -680 {
lab=Di[9]}
N 1540 -660 1560 -660 {
lab=Di[10]}
N 1540 -640 1560 -640 {
lab=Di[11]}
N 1540 -620 1560 -620 {
lab=Di[12]}
N 1540 -600 1560 -600 {
lab=Di[13]}
N 1540 -580 1560 -580 {
lab=Di[14]}
N 1540 -560 1560 -560 {
lab=Di[15]}
N 1540 -540 1560 -540 {
lab=Di[16]}
N 1540 -520 1560 -520 {
lab=Di[17]}
N 1540 -500 1560 -500 {
lab=Di[18]}
N 1540 -480 1560 -480 {
lab=Di[19]}
N 1540 -460 1560 -460 {
lab=Di[20]}
N 1540 -440 1560 -440 {
lab=Di[21]}
N 1540 -420 1560 -420 {
lab=Di[22]}
N 1540 -400 1560 -400 {
lab=Di[23]}
N 1540 -380 1560 -380 {
lab=Di[24]}
N 1540 -360 1560 -360 {
lab=Di[25]}
N 1540 -340 1560 -340 {
lab=Di[26]}
N 1540 -320 1560 -320 {
lab=Di[27]}
N 1540 -300 1560 -300 {
lab=Di[28]}
N 1540 -280 1560 -280 {
lab=Di[29]}
N 1540 -260 1560 -260 {
lab=Di[30]}
N 1540 -240 1560 -240 {
lab=Di[31]}
N 1860 -860 1880 -860 {
lab=Do[0]}
N 1860 -840 1880 -840 {
lab=Do[1]}
N 1860 -820 1880 -820 {
lab=Do[2]}
N 1860 -800 1880 -800 {
lab=Do[3]}
N 1860 -780 1880 -780 {
lab=Do[4]}
N 1860 -760 1880 -760 {
lab=Do[5]}
N 1860 -740 1880 -740 {
lab=Do[6]}
N 1860 -720 1880 -720 {
lab=Do[7]}
N 1860 -700 1880 -700 {
lab=Do[8]}
N 1860 -680 1880 -680 {
lab=Do[9]}
N 1860 -660 1880 -660 {
lab=Do[10]}
N 1860 -640 1880 -640 {
lab=Do[11]}
N 1860 -620 1880 -620 {
lab=Do[12]}
N 1860 -600 1880 -600 {
lab=Do[13]}
N 1860 -580 1880 -580 {
lab=Do[14]}
N 1860 -560 1880 -560 {
lab=Do[15]}
N 1860 -540 1880 -540 {
lab=Do[16]}
N 1860 -520 1880 -520 {
lab=Do[17]}
N 1860 -500 1880 -500 {
lab=Do[18]}
N 1860 -480 1880 -480 {
lab=Do[19]}
N 1860 -460 1880 -460 {
lab=Do[20]}
N 1860 -440 1880 -440 {
lab=Do[21]}
N 1860 -420 1880 -420 {
lab=Do[22]}
N 1860 -400 1880 -400 {
lab=Do[23]}
N 1860 -380 1880 -380 {
lab=Do[24]}
N 1860 -360 1880 -360 {
lab=Do[25]}
N 1860 -340 1880 -340 {
lab=Do[26]}
N 1860 -320 1880 -320 {
lab=Do[27]}
N 1860 -300 1880 -300 {
lab=Do[28]}
N 1860 -280 1880 -280 {
lab=Do[29]}
N 1860 -260 1880 -260 {
lab=Do[30]}
N 1860 -240 1880 -240 {
lab=Do[31]}
N 1630 -920 1630 -900 {
lab=CLK_buf}
N 1650 -920 1650 -900 {
lab=SEL[11]}
N 1670 -920 1670 -900 {
lab=WE[0]}
N 1690 -920 1690 -900 {
lab=WE[1]}
N 1710 -920 1710 -900 {
lab=WE[2]}
N 1730 -920 1730 -900 {
lab=WE[3]}
N 1760 -920 1760 -900 {
lab=VDD}
N 1780 -920 1780 -900 {
lab=VSS}
N 1020 -860 1040 -860 {
lab=Di[0]}
N 1020 -840 1040 -840 {
lab=Di[1]}
N 1020 -820 1040 -820 {
lab=Di[2]}
N 1020 -800 1040 -800 {
lab=Di[3]}
N 1020 -780 1040 -780 {
lab=Di[4]}
N 1020 -760 1040 -760 {
lab=Di[5]}
N 1020 -740 1040 -740 {
lab=Di[6]}
N 1020 -720 1040 -720 {
lab=Di[7]}
N 1020 -700 1040 -700 {
lab=Di[8]}
N 1020 -680 1040 -680 {
lab=Di[9]}
N 1020 -660 1040 -660 {
lab=Di[10]}
N 1020 -640 1040 -640 {
lab=Di[11]}
N 1020 -620 1040 -620 {
lab=Di[12]}
N 1020 -600 1040 -600 {
lab=Di[13]}
N 1020 -580 1040 -580 {
lab=Di[14]}
N 1020 -560 1040 -560 {
lab=Di[15]}
N 1020 -540 1040 -540 {
lab=Di[16]}
N 1020 -520 1040 -520 {
lab=Di[17]}
N 1020 -500 1040 -500 {
lab=Di[18]}
N 1020 -480 1040 -480 {
lab=Di[19]}
N 1020 -460 1040 -460 {
lab=Di[20]}
N 1020 -440 1040 -440 {
lab=Di[21]}
N 1020 -420 1040 -420 {
lab=Di[22]}
N 1020 -400 1040 -400 {
lab=Di[23]}
N 1020 -380 1040 -380 {
lab=Di[24]}
N 1020 -360 1040 -360 {
lab=Di[25]}
N 1020 -340 1040 -340 {
lab=Di[26]}
N 1020 -320 1040 -320 {
lab=Di[27]}
N 1020 -300 1040 -300 {
lab=Di[28]}
N 1020 -280 1040 -280 {
lab=Di[29]}
N 1020 -260 1040 -260 {
lab=Di[30]}
N 1020 -240 1040 -240 {
lab=Di[31]}
N 1340 -860 1360 -860 {
lab=Do[0]}
N 1340 -840 1360 -840 {
lab=Do[1]}
N 1340 -820 1360 -820 {
lab=Do[2]}
N 1340 -800 1360 -800 {
lab=Do[3]}
N 1340 -780 1360 -780 {
lab=Do[4]}
N 1340 -760 1360 -760 {
lab=Do[5]}
N 1340 -740 1360 -740 {
lab=Do[6]}
N 1340 -720 1360 -720 {
lab=Do[7]}
N 1340 -700 1360 -700 {
lab=Do[8]}
N 1340 -680 1360 -680 {
lab=Do[9]}
N 1340 -660 1360 -660 {
lab=Do[10]}
N 1340 -640 1360 -640 {
lab=Do[11]}
N 1340 -620 1360 -620 {
lab=Do[12]}
N 1340 -600 1360 -600 {
lab=Do[13]}
N 1340 -580 1360 -580 {
lab=Do[14]}
N 1340 -560 1360 -560 {
lab=Do[15]}
N 1340 -540 1360 -540 {
lab=Do[16]}
N 1340 -520 1360 -520 {
lab=Do[17]}
N 1340 -500 1360 -500 {
lab=Do[18]}
N 1340 -480 1360 -480 {
lab=Do[19]}
N 1340 -460 1360 -460 {
lab=Do[20]}
N 1340 -440 1360 -440 {
lab=Do[21]}
N 1340 -420 1360 -420 {
lab=Do[22]}
N 1340 -400 1360 -400 {
lab=Do[23]}
N 1340 -380 1360 -380 {
lab=Do[24]}
N 1340 -360 1360 -360 {
lab=Do[25]}
N 1340 -340 1360 -340 {
lab=Do[26]}
N 1340 -320 1360 -320 {
lab=Do[27]}
N 1340 -300 1360 -300 {
lab=Do[28]}
N 1340 -280 1360 -280 {
lab=Do[29]}
N 1340 -260 1360 -260 {
lab=Do[30]}
N 1340 -240 1360 -240 {
lab=Do[31]}
N 1110 -920 1110 -900 {
lab=CLK_buf}
N 1130 -920 1130 -900 {
lab=SEL[10]}
N 1150 -920 1150 -900 {
lab=WE[0]}
N 1170 -920 1170 -900 {
lab=WE[1]}
N 1190 -920 1190 -900 {
lab=WE[2]}
N 1210 -920 1210 -900 {
lab=WE[3]}
N 1240 -920 1240 -900 {
lab=VDD}
N 1260 -920 1260 -900 {
lab=VSS}
N 480 -860 500 -860 {
lab=Di[0]}
N 480 -840 500 -840 {
lab=Di[1]}
N 480 -820 500 -820 {
lab=Di[2]}
N 480 -800 500 -800 {
lab=Di[3]}
N 480 -780 500 -780 {
lab=Di[4]}
N 480 -760 500 -760 {
lab=Di[5]}
N 480 -740 500 -740 {
lab=Di[6]}
N 480 -720 500 -720 {
lab=Di[7]}
N 480 -700 500 -700 {
lab=Di[8]}
N 480 -680 500 -680 {
lab=Di[9]}
N 480 -660 500 -660 {
lab=Di[10]}
N 480 -640 500 -640 {
lab=Di[11]}
N 480 -620 500 -620 {
lab=Di[12]}
N 480 -600 500 -600 {
lab=Di[13]}
N 480 -580 500 -580 {
lab=Di[14]}
N 480 -560 500 -560 {
lab=Di[15]}
N 480 -540 500 -540 {
lab=Di[16]}
N 480 -520 500 -520 {
lab=Di[17]}
N 480 -500 500 -500 {
lab=Di[18]}
N 480 -480 500 -480 {
lab=Di[19]}
N 480 -460 500 -460 {
lab=Di[20]}
N 480 -440 500 -440 {
lab=Di[21]}
N 480 -420 500 -420 {
lab=Di[22]}
N 480 -400 500 -400 {
lab=Di[23]}
N 480 -380 500 -380 {
lab=Di[24]}
N 480 -360 500 -360 {
lab=Di[25]}
N 480 -340 500 -340 {
lab=Di[26]}
N 480 -320 500 -320 {
lab=Di[27]}
N 480 -300 500 -300 {
lab=Di[28]}
N 480 -280 500 -280 {
lab=Di[29]}
N 480 -260 500 -260 {
lab=Di[30]}
N 480 -240 500 -240 {
lab=Di[31]}
N 800 -860 820 -860 {
lab=Do[0]}
N 800 -840 820 -840 {
lab=Do[1]}
N 800 -820 820 -820 {
lab=Do[2]}
N 800 -800 820 -800 {
lab=Do[3]}
N 800 -780 820 -780 {
lab=Do[4]}
N 800 -760 820 -760 {
lab=Do[5]}
N 800 -740 820 -740 {
lab=Do[6]}
N 800 -720 820 -720 {
lab=Do[7]}
N 800 -700 820 -700 {
lab=Do[8]}
N 800 -680 820 -680 {
lab=Do[9]}
N 800 -660 820 -660 {
lab=Do[10]}
N 800 -640 820 -640 {
lab=Do[11]}
N 800 -620 820 -620 {
lab=Do[12]}
N 800 -600 820 -600 {
lab=Do[13]}
N 800 -580 820 -580 {
lab=Do[14]}
N 800 -560 820 -560 {
lab=Do[15]}
N 800 -540 820 -540 {
lab=Do[16]}
N 800 -520 820 -520 {
lab=Do[17]}
N 800 -500 820 -500 {
lab=Do[18]}
N 800 -480 820 -480 {
lab=Do[19]}
N 800 -460 820 -460 {
lab=Do[20]}
N 800 -440 820 -440 {
lab=Do[21]}
N 800 -420 820 -420 {
lab=Do[22]}
N 800 -400 820 -400 {
lab=Do[23]}
N 800 -380 820 -380 {
lab=Do[24]}
N 800 -360 820 -360 {
lab=Do[25]}
N 800 -340 820 -340 {
lab=Do[26]}
N 800 -320 820 -320 {
lab=Do[27]}
N 800 -300 820 -300 {
lab=Do[28]}
N 800 -280 820 -280 {
lab=Do[29]}
N 800 -260 820 -260 {
lab=Do[30]}
N 800 -240 820 -240 {
lab=Do[31]}
N 570 -920 570 -900 {
lab=CLK_buf}
N 590 -920 590 -900 {
lab=SEL[9]}
N 610 -920 610 -900 {
lab=WE[0]}
N 630 -920 630 -900 {
lab=WE[1]}
N 650 -920 650 -900 {
lab=WE[2]}
N 670 -920 670 -900 {
lab=WE[3]}
N 700 -920 700 -900 {
lab=VDD}
N 720 -920 720 -900 {
lab=VSS}
N -40 -860 -20 -860 {
lab=Di[0]}
N -40 -840 -20 -840 {
lab=Di[1]}
N -40 -820 -20 -820 {
lab=Di[2]}
N -40 -800 -20 -800 {
lab=Di[3]}
N -40 -780 -20 -780 {
lab=Di[4]}
N -40 -760 -20 -760 {
lab=Di[5]}
N -40 -740 -20 -740 {
lab=Di[6]}
N -40 -720 -20 -720 {
lab=Di[7]}
N -40 -700 -20 -700 {
lab=Di[8]}
N -40 -680 -20 -680 {
lab=Di[9]}
N -40 -660 -20 -660 {
lab=Di[10]}
N -40 -640 -20 -640 {
lab=Di[11]}
N -40 -620 -20 -620 {
lab=Di[12]}
N -40 -600 -20 -600 {
lab=Di[13]}
N -40 -580 -20 -580 {
lab=Di[14]}
N -40 -560 -20 -560 {
lab=Di[15]}
N -40 -540 -20 -540 {
lab=Di[16]}
N -40 -520 -20 -520 {
lab=Di[17]}
N -40 -500 -20 -500 {
lab=Di[18]}
N -40 -480 -20 -480 {
lab=Di[19]}
N -40 -460 -20 -460 {
lab=Di[20]}
N -40 -440 -20 -440 {
lab=Di[21]}
N -40 -420 -20 -420 {
lab=Di[22]}
N -40 -400 -20 -400 {
lab=Di[23]}
N -40 -380 -20 -380 {
lab=Di[24]}
N -40 -360 -20 -360 {
lab=Di[25]}
N -40 -340 -20 -340 {
lab=Di[26]}
N -40 -320 -20 -320 {
lab=Di[27]}
N -40 -300 -20 -300 {
lab=Di[28]}
N -40 -280 -20 -280 {
lab=Di[29]}
N -40 -260 -20 -260 {
lab=Di[30]}
N -40 -240 -20 -240 {
lab=Di[31]}
N 280 -860 300 -860 {
lab=Do[0]}
N 280 -840 300 -840 {
lab=Do[1]}
N 280 -820 300 -820 {
lab=Do[2]}
N 280 -800 300 -800 {
lab=Do[3]}
N 280 -780 300 -780 {
lab=Do[4]}
N 280 -760 300 -760 {
lab=Do[5]}
N 280 -740 300 -740 {
lab=Do[6]}
N 280 -720 300 -720 {
lab=Do[7]}
N 280 -700 300 -700 {
lab=Do[8]}
N 280 -680 300 -680 {
lab=Do[9]}
N 280 -660 300 -660 {
lab=Do[10]}
N 280 -640 300 -640 {
lab=Do[11]}
N 280 -620 300 -620 {
lab=Do[12]}
N 280 -600 300 -600 {
lab=Do[13]}
N 280 -580 300 -580 {
lab=Do[14]}
N 280 -560 300 -560 {
lab=Do[15]}
N 280 -540 300 -540 {
lab=Do[16]}
N 280 -520 300 -520 {
lab=Do[17]}
N 280 -500 300 -500 {
lab=Do[18]}
N 280 -480 300 -480 {
lab=Do[19]}
N 280 -460 300 -460 {
lab=Do[20]}
N 280 -440 300 -440 {
lab=Do[21]}
N 280 -420 300 -420 {
lab=Do[22]}
N 280 -400 300 -400 {
lab=Do[23]}
N 280 -380 300 -380 {
lab=Do[24]}
N 280 -360 300 -360 {
lab=Do[25]}
N 280 -340 300 -340 {
lab=Do[26]}
N 280 -320 300 -320 {
lab=Do[27]}
N 280 -300 300 -300 {
lab=Do[28]}
N 280 -280 300 -280 {
lab=Do[29]}
N 280 -260 300 -260 {
lab=Do[30]}
N 280 -240 300 -240 {
lab=Do[31]}
N 50 -920 50 -900 {
lab=CLK_buf}
N 70 -920 70 -900 {
lab=SEL[8]}
N 90 -920 90 -900 {
lab=WE[0]}
N 110 -920 110 -900 {
lab=WE[1]}
N 130 -920 130 -900 {
lab=WE[2]}
N 150 -920 150 -900 {
lab=WE[3]}
N 180 -920 180 -900 {
lab=VDD}
N 200 -920 200 -900 {
lab=VSS}
N -30 90 -10 90 {
lab=Di[0]}
N -30 110 -10 110 {
lab=Di[1]}
N -30 130 -10 130 {
lab=Di[2]}
N -30 150 -10 150 {
lab=Di[3]}
N -30 170 -10 170 {
lab=Di[4]}
N -30 190 -10 190 {
lab=Di[5]}
N -30 210 -10 210 {
lab=Di[6]}
N -30 230 -10 230 {
lab=Di[7]}
N -30 250 -10 250 {
lab=Di[8]}
N -30 270 -10 270 {
lab=Di[9]}
N -30 290 -10 290 {
lab=Di[10]}
N -30 310 -10 310 {
lab=Di[11]}
N -30 330 -10 330 {
lab=Di[12]}
N -30 350 -10 350 {
lab=Di[13]}
N -30 370 -10 370 {
lab=Di[14]}
N -30 390 -10 390 {
lab=Di[15]}
N -30 410 -10 410 {
lab=Di[16]}
N -30 430 -10 430 {
lab=Di[17]}
N -30 450 -10 450 {
lab=Di[18]}
N -30 470 -10 470 {
lab=Di[19]}
N -30 490 -10 490 {
lab=Di[20]}
N -30 510 -10 510 {
lab=Di[21]}
N -30 530 -10 530 {
lab=Di[22]}
N -30 550 -10 550 {
lab=Di[23]}
N -30 570 -10 570 {
lab=Di[24]}
N -30 590 -10 590 {
lab=Di[25]}
N -30 610 -10 610 {
lab=Di[26]}
N -30 630 -10 630 {
lab=Di[27]}
N -30 650 -10 650 {
lab=Di[28]}
N -30 670 -10 670 {
lab=Di[29]}
N -30 690 -10 690 {
lab=Di[30]}
N -30 710 -10 710 {
lab=Di[31]}
N 290 90 310 90 {
lab=Do[0]}
N 290 110 310 110 {
lab=Do[1]}
N 290 130 310 130 {
lab=Do[2]}
N 290 150 310 150 {
lab=Do[3]}
N 290 170 310 170 {
lab=Do[4]}
N 290 190 310 190 {
lab=Do[5]}
N 290 210 310 210 {
lab=Do[6]}
N 290 230 310 230 {
lab=Do[7]}
N 290 250 310 250 {
lab=Do[8]}
N 290 270 310 270 {
lab=Do[9]}
N 290 290 310 290 {
lab=Do[10]}
N 290 310 310 310 {
lab=Do[11]}
N 290 330 310 330 {
lab=Do[12]}
N 290 350 310 350 {
lab=Do[13]}
N 290 370 310 370 {
lab=Do[14]}
N 290 390 310 390 {
lab=Do[15]}
N 290 410 310 410 {
lab=Do[16]}
N 290 430 310 430 {
lab=Do[17]}
N 290 450 310 450 {
lab=Do[18]}
N 290 470 310 470 {
lab=Do[19]}
N 290 490 310 490 {
lab=Do[20]}
N 290 510 310 510 {
lab=Do[21]}
N 290 530 310 530 {
lab=Do[22]}
N 290 550 310 550 {
lab=Do[23]}
N 290 570 310 570 {
lab=Do[24]}
N 290 590 310 590 {
lab=Do[25]}
N 290 610 310 610 {
lab=Do[26]}
N 290 630 310 630 {
lab=Do[27]}
N 290 650 310 650 {
lab=Do[28]}
N 290 670 310 670 {
lab=Do[29]}
N 290 690 310 690 {
lab=Do[30]}
N 290 710 310 710 {
lab=Do[31]}
N 60 30 60 50 {
lab=CLK_buf}
N 80 30 80 50 {
lab=SEL[16]}
N 100 30 100 50 {
lab=WE[0]}
N 120 30 120 50 {
lab=WE[1]}
N 140 30 140 50 {
lab=WE[2]}
N 160 30 160 50 {
lab=WE[3]}
N 190 30 190 50 {
lab=VDD}
N 210 30 210 50 {
lab=VSS}
N 490 90 510 90 {
lab=Di[0]}
N 490 110 510 110 {
lab=Di[1]}
N 490 130 510 130 {
lab=Di[2]}
N 490 150 510 150 {
lab=Di[3]}
N 490 170 510 170 {
lab=Di[4]}
N 490 190 510 190 {
lab=Di[5]}
N 490 210 510 210 {
lab=Di[6]}
N 490 230 510 230 {
lab=Di[7]}
N 490 250 510 250 {
lab=Di[8]}
N 490 270 510 270 {
lab=Di[9]}
N 490 290 510 290 {
lab=Di[10]}
N 490 310 510 310 {
lab=Di[11]}
N 490 330 510 330 {
lab=Di[12]}
N 490 350 510 350 {
lab=Di[13]}
N 490 370 510 370 {
lab=Di[14]}
N 490 390 510 390 {
lab=Di[15]}
N 490 410 510 410 {
lab=Di[16]}
N 490 430 510 430 {
lab=Di[17]}
N 490 450 510 450 {
lab=Di[18]}
N 490 470 510 470 {
lab=Di[19]}
N 490 490 510 490 {
lab=Di[20]}
N 490 510 510 510 {
lab=Di[21]}
N 490 530 510 530 {
lab=Di[22]}
N 490 550 510 550 {
lab=Di[23]}
N 490 570 510 570 {
lab=Di[24]}
N 490 590 510 590 {
lab=Di[25]}
N 490 610 510 610 {
lab=Di[26]}
N 490 630 510 630 {
lab=Di[27]}
N 490 650 510 650 {
lab=Di[28]}
N 490 670 510 670 {
lab=Di[29]}
N 490 690 510 690 {
lab=Di[30]}
N 490 710 510 710 {
lab=Di[31]}
N 810 90 830 90 {
lab=Do[0]}
N 810 110 830 110 {
lab=Do[1]}
N 810 130 830 130 {
lab=Do[2]}
N 810 150 830 150 {
lab=Do[3]}
N 810 170 830 170 {
lab=Do[4]}
N 810 190 830 190 {
lab=Do[5]}
N 810 210 830 210 {
lab=Do[6]}
N 810 230 830 230 {
lab=Do[7]}
N 810 250 830 250 {
lab=Do[8]}
N 810 270 830 270 {
lab=Do[9]}
N 810 290 830 290 {
lab=Do[10]}
N 810 310 830 310 {
lab=Do[11]}
N 810 330 830 330 {
lab=Do[12]}
N 810 350 830 350 {
lab=Do[13]}
N 810 370 830 370 {
lab=Do[14]}
N 810 390 830 390 {
lab=Do[15]}
N 810 410 830 410 {
lab=Do[16]}
N 810 430 830 430 {
lab=Do[17]}
N 810 450 830 450 {
lab=Do[18]}
N 810 470 830 470 {
lab=Do[19]}
N 810 490 830 490 {
lab=Do[20]}
N 810 510 830 510 {
lab=Do[21]}
N 810 530 830 530 {
lab=Do[22]}
N 810 550 830 550 {
lab=Do[23]}
N 810 570 830 570 {
lab=Do[24]}
N 810 590 830 590 {
lab=Do[25]}
N 810 610 830 610 {
lab=Do[26]}
N 810 630 830 630 {
lab=Do[27]}
N 810 650 830 650 {
lab=Do[28]}
N 810 670 830 670 {
lab=Do[29]}
N 810 690 830 690 {
lab=Do[30]}
N 810 710 830 710 {
lab=Do[31]}
N 580 30 580 50 {
lab=CLK_buf}
N 600 30 600 50 {
lab=SEL[17]}
N 620 30 620 50 {
lab=WE[0]}
N 640 30 640 50 {
lab=WE[1]}
N 660 30 660 50 {
lab=WE[2]}
N 680 30 680 50 {
lab=WE[3]}
N 710 30 710 50 {
lab=VDD}
N 730 30 730 50 {
lab=VSS}
N 1030 90 1050 90 {
lab=Di[0]}
N 1030 110 1050 110 {
lab=Di[1]}
N 1030 130 1050 130 {
lab=Di[2]}
N 1030 150 1050 150 {
lab=Di[3]}
N 1030 170 1050 170 {
lab=Di[4]}
N 1030 190 1050 190 {
lab=Di[5]}
N 1030 210 1050 210 {
lab=Di[6]}
N 1030 230 1050 230 {
lab=Di[7]}
N 1030 250 1050 250 {
lab=Di[8]}
N 1030 270 1050 270 {
lab=Di[9]}
N 1030 290 1050 290 {
lab=Di[10]}
N 1030 310 1050 310 {
lab=Di[11]}
N 1030 330 1050 330 {
lab=Di[12]}
N 1030 350 1050 350 {
lab=Di[13]}
N 1030 370 1050 370 {
lab=Di[14]}
N 1030 390 1050 390 {
lab=Di[15]}
N 1030 410 1050 410 {
lab=Di[16]}
N 1030 430 1050 430 {
lab=Di[17]}
N 1030 450 1050 450 {
lab=Di[18]}
N 1030 470 1050 470 {
lab=Di[19]}
N 1030 490 1050 490 {
lab=Di[20]}
N 1030 510 1050 510 {
lab=Di[21]}
N 1030 530 1050 530 {
lab=Di[22]}
N 1030 550 1050 550 {
lab=Di[23]}
N 1030 570 1050 570 {
lab=Di[24]}
N 1030 590 1050 590 {
lab=Di[25]}
N 1030 610 1050 610 {
lab=Di[26]}
N 1030 630 1050 630 {
lab=Di[27]}
N 1030 650 1050 650 {
lab=Di[28]}
N 1030 670 1050 670 {
lab=Di[29]}
N 1030 690 1050 690 {
lab=Di[30]}
N 1030 710 1050 710 {
lab=Di[31]}
N 1350 90 1370 90 {
lab=Do[0]}
N 1350 110 1370 110 {
lab=Do[1]}
N 1350 130 1370 130 {
lab=Do[2]}
N 1350 150 1370 150 {
lab=Do[3]}
N 1350 170 1370 170 {
lab=Do[4]}
N 1350 190 1370 190 {
lab=Do[5]}
N 1350 210 1370 210 {
lab=Do[6]}
N 1350 230 1370 230 {
lab=Do[7]}
N 1350 250 1370 250 {
lab=Do[8]}
N 1350 270 1370 270 {
lab=Do[9]}
N 1350 290 1370 290 {
lab=Do[10]}
N 1350 310 1370 310 {
lab=Do[11]}
N 1350 330 1370 330 {
lab=Do[12]}
N 1350 350 1370 350 {
lab=Do[13]}
N 1350 370 1370 370 {
lab=Do[14]}
N 1350 390 1370 390 {
lab=Do[15]}
N 1350 410 1370 410 {
lab=Do[16]}
N 1350 430 1370 430 {
lab=Do[17]}
N 1350 450 1370 450 {
lab=Do[18]}
N 1350 470 1370 470 {
lab=Do[19]}
N 1350 490 1370 490 {
lab=Do[20]}
N 1350 510 1370 510 {
lab=Do[21]}
N 1350 530 1370 530 {
lab=Do[22]}
N 1350 550 1370 550 {
lab=Do[23]}
N 1350 570 1370 570 {
lab=Do[24]}
N 1350 590 1370 590 {
lab=Do[25]}
N 1350 610 1370 610 {
lab=Do[26]}
N 1350 630 1370 630 {
lab=Do[27]}
N 1350 650 1370 650 {
lab=Do[28]}
N 1350 670 1370 670 {
lab=Do[29]}
N 1350 690 1370 690 {
lab=Do[30]}
N 1350 710 1370 710 {
lab=Do[31]}
N 1120 30 1120 50 {
lab=CLK_buf}
N 1140 30 1140 50 {
lab=SEL[18]}
N 1160 30 1160 50 {
lab=WE[0]}
N 1180 30 1180 50 {
lab=WE[1]}
N 1200 30 1200 50 {
lab=WE[2]}
N 1220 30 1220 50 {
lab=WE[3]}
N 1250 30 1250 50 {
lab=VDD}
N 1270 30 1270 50 {
lab=VSS}
N 1550 90 1570 90 {
lab=Di[0]}
N 1550 110 1570 110 {
lab=Di[1]}
N 1550 130 1570 130 {
lab=Di[2]}
N 1550 150 1570 150 {
lab=Di[3]}
N 1550 170 1570 170 {
lab=Di[4]}
N 1550 190 1570 190 {
lab=Di[5]}
N 1550 210 1570 210 {
lab=Di[6]}
N 1550 230 1570 230 {
lab=Di[7]}
N 1550 250 1570 250 {
lab=Di[8]}
N 1550 270 1570 270 {
lab=Di[9]}
N 1550 290 1570 290 {
lab=Di[10]}
N 1550 310 1570 310 {
lab=Di[11]}
N 1550 330 1570 330 {
lab=Di[12]}
N 1550 350 1570 350 {
lab=Di[13]}
N 1550 370 1570 370 {
lab=Di[14]}
N 1550 390 1570 390 {
lab=Di[15]}
N 1550 410 1570 410 {
lab=Di[16]}
N 1550 430 1570 430 {
lab=Di[17]}
N 1550 450 1570 450 {
lab=Di[18]}
N 1550 470 1570 470 {
lab=Di[19]}
N 1550 490 1570 490 {
lab=Di[20]}
N 1550 510 1570 510 {
lab=Di[21]}
N 1550 530 1570 530 {
lab=Di[22]}
N 1550 550 1570 550 {
lab=Di[23]}
N 1550 570 1570 570 {
lab=Di[24]}
N 1550 590 1570 590 {
lab=Di[25]}
N 1550 610 1570 610 {
lab=Di[26]}
N 1550 630 1570 630 {
lab=Di[27]}
N 1550 650 1570 650 {
lab=Di[28]}
N 1550 670 1570 670 {
lab=Di[29]}
N 1550 690 1570 690 {
lab=Di[30]}
N 1550 710 1570 710 {
lab=Di[31]}
N 1870 90 1890 90 {
lab=Do[0]}
N 1870 110 1890 110 {
lab=Do[1]}
N 1870 130 1890 130 {
lab=Do[2]}
N 1870 150 1890 150 {
lab=Do[3]}
N 1870 170 1890 170 {
lab=Do[4]}
N 1870 190 1890 190 {
lab=Do[5]}
N 1870 210 1890 210 {
lab=Do[6]}
N 1870 230 1890 230 {
lab=Do[7]}
N 1870 250 1890 250 {
lab=Do[8]}
N 1870 270 1890 270 {
lab=Do[9]}
N 1870 290 1890 290 {
lab=Do[10]}
N 1870 310 1890 310 {
lab=Do[11]}
N 1870 330 1890 330 {
lab=Do[12]}
N 1870 350 1890 350 {
lab=Do[13]}
N 1870 370 1890 370 {
lab=Do[14]}
N 1870 390 1890 390 {
lab=Do[15]}
N 1870 410 1890 410 {
lab=Do[16]}
N 1870 430 1890 430 {
lab=Do[17]}
N 1870 450 1890 450 {
lab=Do[18]}
N 1870 470 1890 470 {
lab=Do[19]}
N 1870 490 1890 490 {
lab=Do[20]}
N 1870 510 1890 510 {
lab=Do[21]}
N 1870 530 1890 530 {
lab=Do[22]}
N 1870 550 1890 550 {
lab=Do[23]}
N 1870 570 1890 570 {
lab=Do[24]}
N 1870 590 1890 590 {
lab=Do[25]}
N 1870 610 1890 610 {
lab=Do[26]}
N 1870 630 1890 630 {
lab=Do[27]}
N 1870 650 1890 650 {
lab=Do[28]}
N 1870 670 1890 670 {
lab=Do[29]}
N 1870 690 1890 690 {
lab=Do[30]}
N 1870 710 1890 710 {
lab=Do[31]}
N 1640 30 1640 50 {
lab=CLK_buf}
N 1660 30 1660 50 {
lab=SEL[19]}
N 1680 30 1680 50 {
lab=WE[0]}
N 1700 30 1700 50 {
lab=WE[1]}
N 1720 30 1720 50 {
lab=WE[2]}
N 1740 30 1740 50 {
lab=WE[3]}
N 1770 30 1770 50 {
lab=VDD}
N 1790 30 1790 50 {
lab=VSS}
N 2070 90 2090 90 {
lab=Di[0]}
N 2070 110 2090 110 {
lab=Di[1]}
N 2070 130 2090 130 {
lab=Di[2]}
N 2070 150 2090 150 {
lab=Di[3]}
N 2070 170 2090 170 {
lab=Di[4]}
N 2070 190 2090 190 {
lab=Di[5]}
N 2070 210 2090 210 {
lab=Di[6]}
N 2070 230 2090 230 {
lab=Di[7]}
N 2070 250 2090 250 {
lab=Di[8]}
N 2070 270 2090 270 {
lab=Di[9]}
N 2070 290 2090 290 {
lab=Di[10]}
N 2070 310 2090 310 {
lab=Di[11]}
N 2070 330 2090 330 {
lab=Di[12]}
N 2070 350 2090 350 {
lab=Di[13]}
N 2070 370 2090 370 {
lab=Di[14]}
N 2070 390 2090 390 {
lab=Di[15]}
N 2070 410 2090 410 {
lab=Di[16]}
N 2070 430 2090 430 {
lab=Di[17]}
N 2070 450 2090 450 {
lab=Di[18]}
N 2070 470 2090 470 {
lab=Di[19]}
N 2070 490 2090 490 {
lab=Di[20]}
N 2070 510 2090 510 {
lab=Di[21]}
N 2070 530 2090 530 {
lab=Di[22]}
N 2070 550 2090 550 {
lab=Di[23]}
N 2070 570 2090 570 {
lab=Di[24]}
N 2070 590 2090 590 {
lab=Di[25]}
N 2070 610 2090 610 {
lab=Di[26]}
N 2070 630 2090 630 {
lab=Di[27]}
N 2070 650 2090 650 {
lab=Di[28]}
N 2070 670 2090 670 {
lab=Di[29]}
N 2070 690 2090 690 {
lab=Di[30]}
N 2070 710 2090 710 {
lab=Di[31]}
N 2390 90 2410 90 {
lab=Do[0]}
N 2390 110 2410 110 {
lab=Do[1]}
N 2390 130 2410 130 {
lab=Do[2]}
N 2390 150 2410 150 {
lab=Do[3]}
N 2390 170 2410 170 {
lab=Do[4]}
N 2390 190 2410 190 {
lab=Do[5]}
N 2390 210 2410 210 {
lab=Do[6]}
N 2390 230 2410 230 {
lab=Do[7]}
N 2390 250 2410 250 {
lab=Do[8]}
N 2390 270 2410 270 {
lab=Do[9]}
N 2390 290 2410 290 {
lab=Do[10]}
N 2390 310 2410 310 {
lab=Do[11]}
N 2390 330 2410 330 {
lab=Do[12]}
N 2390 350 2410 350 {
lab=Do[13]}
N 2390 370 2410 370 {
lab=Do[14]}
N 2390 390 2410 390 {
lab=Do[15]}
N 2390 410 2410 410 {
lab=Do[16]}
N 2390 430 2410 430 {
lab=Do[17]}
N 2390 450 2410 450 {
lab=Do[18]}
N 2390 470 2410 470 {
lab=Do[19]}
N 2390 490 2410 490 {
lab=Do[20]}
N 2390 510 2410 510 {
lab=Do[21]}
N 2390 530 2410 530 {
lab=Do[22]}
N 2390 550 2410 550 {
lab=Do[23]}
N 2390 570 2410 570 {
lab=Do[24]}
N 2390 590 2410 590 {
lab=Do[25]}
N 2390 610 2410 610 {
lab=Do[26]}
N 2390 630 2410 630 {
lab=Do[27]}
N 2390 650 2410 650 {
lab=Do[28]}
N 2390 670 2410 670 {
lab=Do[29]}
N 2390 690 2410 690 {
lab=Do[30]}
N 2390 710 2410 710 {
lab=Do[31]}
N 2160 30 2160 50 {
lab=CLK_buf}
N 2180 30 2180 50 {
lab=SEL[20]}
N 2200 30 2200 50 {
lab=WE[0]}
N 2220 30 2220 50 {
lab=WE[1]}
N 2240 30 2240 50 {
lab=WE[2]}
N 2260 30 2260 50 {
lab=WE[3]}
N 2290 30 2290 50 {
lab=VDD}
N 2310 30 2310 50 {
lab=VSS}
N 2590 90 2610 90 {
lab=Di[0]}
N 2590 110 2610 110 {
lab=Di[1]}
N 2590 130 2610 130 {
lab=Di[2]}
N 2590 150 2610 150 {
lab=Di[3]}
N 2590 170 2610 170 {
lab=Di[4]}
N 2590 190 2610 190 {
lab=Di[5]}
N 2590 210 2610 210 {
lab=Di[6]}
N 2590 230 2610 230 {
lab=Di[7]}
N 2590 250 2610 250 {
lab=Di[8]}
N 2590 270 2610 270 {
lab=Di[9]}
N 2590 290 2610 290 {
lab=Di[10]}
N 2590 310 2610 310 {
lab=Di[11]}
N 2590 330 2610 330 {
lab=Di[12]}
N 2590 350 2610 350 {
lab=Di[13]}
N 2590 370 2610 370 {
lab=Di[14]}
N 2590 390 2610 390 {
lab=Di[15]}
N 2590 410 2610 410 {
lab=Di[16]}
N 2590 430 2610 430 {
lab=Di[17]}
N 2590 450 2610 450 {
lab=Di[18]}
N 2590 470 2610 470 {
lab=Di[19]}
N 2590 490 2610 490 {
lab=Di[20]}
N 2590 510 2610 510 {
lab=Di[21]}
N 2590 530 2610 530 {
lab=Di[22]}
N 2590 550 2610 550 {
lab=Di[23]}
N 2590 570 2610 570 {
lab=Di[24]}
N 2590 590 2610 590 {
lab=Di[25]}
N 2590 610 2610 610 {
lab=Di[26]}
N 2590 630 2610 630 {
lab=Di[27]}
N 2590 650 2610 650 {
lab=Di[28]}
N 2590 670 2610 670 {
lab=Di[29]}
N 2590 690 2610 690 {
lab=Di[30]}
N 2590 710 2610 710 {
lab=Di[31]}
N 2910 90 2930 90 {
lab=Do[0]}
N 2910 110 2930 110 {
lab=Do[1]}
N 2910 130 2930 130 {
lab=Do[2]}
N 2910 150 2930 150 {
lab=Do[3]}
N 2910 170 2930 170 {
lab=Do[4]}
N 2910 190 2930 190 {
lab=Do[5]}
N 2910 210 2930 210 {
lab=Do[6]}
N 2910 230 2930 230 {
lab=Do[7]}
N 2910 250 2930 250 {
lab=Do[8]}
N 2910 270 2930 270 {
lab=Do[9]}
N 2910 290 2930 290 {
lab=Do[10]}
N 2910 310 2930 310 {
lab=Do[11]}
N 2910 330 2930 330 {
lab=Do[12]}
N 2910 350 2930 350 {
lab=Do[13]}
N 2910 370 2930 370 {
lab=Do[14]}
N 2910 390 2930 390 {
lab=Do[15]}
N 2910 410 2930 410 {
lab=Do[16]}
N 2910 430 2930 430 {
lab=Do[17]}
N 2910 450 2930 450 {
lab=Do[18]}
N 2910 470 2930 470 {
lab=Do[19]}
N 2910 490 2930 490 {
lab=Do[20]}
N 2910 510 2930 510 {
lab=Do[21]}
N 2910 530 2930 530 {
lab=Do[22]}
N 2910 550 2930 550 {
lab=Do[23]}
N 2910 570 2930 570 {
lab=Do[24]}
N 2910 590 2930 590 {
lab=Do[25]}
N 2910 610 2930 610 {
lab=Do[26]}
N 2910 630 2930 630 {
lab=Do[27]}
N 2910 650 2930 650 {
lab=Do[28]}
N 2910 670 2930 670 {
lab=Do[29]}
N 2910 690 2930 690 {
lab=Do[30]}
N 2910 710 2930 710 {
lab=Do[31]}
N 2680 30 2680 50 {
lab=CLK_buf}
N 2700 30 2700 50 {
lab=SEL[21]}
N 2720 30 2720 50 {
lab=WE[0]}
N 2740 30 2740 50 {
lab=WE[1]}
N 2760 30 2760 50 {
lab=WE[2]}
N 2780 30 2780 50 {
lab=WE[3]}
N 2810 30 2810 50 {
lab=VDD}
N 2830 30 2830 50 {
lab=VSS}
N 3130 90 3150 90 {
lab=Di[0]}
N 3130 110 3150 110 {
lab=Di[1]}
N 3130 130 3150 130 {
lab=Di[2]}
N 3130 150 3150 150 {
lab=Di[3]}
N 3130 170 3150 170 {
lab=Di[4]}
N 3130 190 3150 190 {
lab=Di[5]}
N 3130 210 3150 210 {
lab=Di[6]}
N 3130 230 3150 230 {
lab=Di[7]}
N 3130 250 3150 250 {
lab=Di[8]}
N 3130 270 3150 270 {
lab=Di[9]}
N 3130 290 3150 290 {
lab=Di[10]}
N 3130 310 3150 310 {
lab=Di[11]}
N 3130 330 3150 330 {
lab=Di[12]}
N 3130 350 3150 350 {
lab=Di[13]}
N 3130 370 3150 370 {
lab=Di[14]}
N 3130 390 3150 390 {
lab=Di[15]}
N 3130 410 3150 410 {
lab=Di[16]}
N 3130 430 3150 430 {
lab=Di[17]}
N 3130 450 3150 450 {
lab=Di[18]}
N 3130 470 3150 470 {
lab=Di[19]}
N 3130 490 3150 490 {
lab=Di[20]}
N 3130 510 3150 510 {
lab=Di[21]}
N 3130 530 3150 530 {
lab=Di[22]}
N 3130 550 3150 550 {
lab=Di[23]}
N 3130 570 3150 570 {
lab=Di[24]}
N 3130 590 3150 590 {
lab=Di[25]}
N 3130 610 3150 610 {
lab=Di[26]}
N 3130 630 3150 630 {
lab=Di[27]}
N 3130 650 3150 650 {
lab=Di[28]}
N 3130 670 3150 670 {
lab=Di[29]}
N 3130 690 3150 690 {
lab=Di[30]}
N 3130 710 3150 710 {
lab=Di[31]}
N 3450 90 3470 90 {
lab=Do[0]}
N 3450 110 3470 110 {
lab=Do[1]}
N 3450 130 3470 130 {
lab=Do[2]}
N 3450 150 3470 150 {
lab=Do[3]}
N 3450 170 3470 170 {
lab=Do[4]}
N 3450 190 3470 190 {
lab=Do[5]}
N 3450 210 3470 210 {
lab=Do[6]}
N 3450 230 3470 230 {
lab=Do[7]}
N 3450 250 3470 250 {
lab=Do[8]}
N 3450 270 3470 270 {
lab=Do[9]}
N 3450 290 3470 290 {
lab=Do[10]}
N 3450 310 3470 310 {
lab=Do[11]}
N 3450 330 3470 330 {
lab=Do[12]}
N 3450 350 3470 350 {
lab=Do[13]}
N 3450 370 3470 370 {
lab=Do[14]}
N 3450 390 3470 390 {
lab=Do[15]}
N 3450 410 3470 410 {
lab=Do[16]}
N 3450 430 3470 430 {
lab=Do[17]}
N 3450 450 3470 450 {
lab=Do[18]}
N 3450 470 3470 470 {
lab=Do[19]}
N 3450 490 3470 490 {
lab=Do[20]}
N 3450 510 3470 510 {
lab=Do[21]}
N 3450 530 3470 530 {
lab=Do[22]}
N 3450 550 3470 550 {
lab=Do[23]}
N 3450 570 3470 570 {
lab=Do[24]}
N 3450 590 3470 590 {
lab=Do[25]}
N 3450 610 3470 610 {
lab=Do[26]}
N 3450 630 3470 630 {
lab=Do[27]}
N 3450 650 3470 650 {
lab=Do[28]}
N 3450 670 3470 670 {
lab=Do[29]}
N 3450 690 3470 690 {
lab=Do[30]}
N 3450 710 3470 710 {
lab=Do[31]}
N 3220 30 3220 50 {
lab=CLK_buf}
N 3240 30 3240 50 {
lab=SEL[22]}
N 3260 30 3260 50 {
lab=WE[0]}
N 3280 30 3280 50 {
lab=WE[1]}
N 3300 30 3300 50 {
lab=WE[2]}
N 3320 30 3320 50 {
lab=WE[3]}
N 3350 30 3350 50 {
lab=VDD}
N 3370 30 3370 50 {
lab=VSS}
N 3650 90 3670 90 {
lab=Di[0]}
N 3650 110 3670 110 {
lab=Di[1]}
N 3650 130 3670 130 {
lab=Di[2]}
N 3650 150 3670 150 {
lab=Di[3]}
N 3650 170 3670 170 {
lab=Di[4]}
N 3650 190 3670 190 {
lab=Di[5]}
N 3650 210 3670 210 {
lab=Di[6]}
N 3650 230 3670 230 {
lab=Di[7]}
N 3650 250 3670 250 {
lab=Di[8]}
N 3650 270 3670 270 {
lab=Di[9]}
N 3650 290 3670 290 {
lab=Di[10]}
N 3650 310 3670 310 {
lab=Di[11]}
N 3650 330 3670 330 {
lab=Di[12]}
N 3650 350 3670 350 {
lab=Di[13]}
N 3650 370 3670 370 {
lab=Di[14]}
N 3650 390 3670 390 {
lab=Di[15]}
N 3650 410 3670 410 {
lab=Di[16]}
N 3650 430 3670 430 {
lab=Di[17]}
N 3650 450 3670 450 {
lab=Di[18]}
N 3650 470 3670 470 {
lab=Di[19]}
N 3650 490 3670 490 {
lab=Di[20]}
N 3650 510 3670 510 {
lab=Di[21]}
N 3650 530 3670 530 {
lab=Di[22]}
N 3650 550 3670 550 {
lab=Di[23]}
N 3650 570 3670 570 {
lab=Di[24]}
N 3650 590 3670 590 {
lab=Di[25]}
N 3650 610 3670 610 {
lab=Di[26]}
N 3650 630 3670 630 {
lab=Di[27]}
N 3650 650 3670 650 {
lab=Di[28]}
N 3650 670 3670 670 {
lab=Di[29]}
N 3650 690 3670 690 {
lab=Di[30]}
N 3650 710 3670 710 {
lab=Di[31]}
N 3970 90 3990 90 {
lab=Do[0]}
N 3970 110 3990 110 {
lab=Do[1]}
N 3970 130 3990 130 {
lab=Do[2]}
N 3970 150 3990 150 {
lab=Do[3]}
N 3970 170 3990 170 {
lab=Do[4]}
N 3970 190 3990 190 {
lab=Do[5]}
N 3970 210 3990 210 {
lab=Do[6]}
N 3970 230 3990 230 {
lab=Do[7]}
N 3970 250 3990 250 {
lab=Do[8]}
N 3970 270 3990 270 {
lab=Do[9]}
N 3970 290 3990 290 {
lab=Do[10]}
N 3970 310 3990 310 {
lab=Do[11]}
N 3970 330 3990 330 {
lab=Do[12]}
N 3970 350 3990 350 {
lab=Do[13]}
N 3970 370 3990 370 {
lab=Do[14]}
N 3970 390 3990 390 {
lab=Do[15]}
N 3970 410 3990 410 {
lab=Do[16]}
N 3970 430 3990 430 {
lab=Do[17]}
N 3970 450 3990 450 {
lab=Do[18]}
N 3970 470 3990 470 {
lab=Do[19]}
N 3970 490 3990 490 {
lab=Do[20]}
N 3970 510 3990 510 {
lab=Do[21]}
N 3970 530 3990 530 {
lab=Do[22]}
N 3970 550 3990 550 {
lab=Do[23]}
N 3970 570 3990 570 {
lab=Do[24]}
N 3970 590 3990 590 {
lab=Do[25]}
N 3970 610 3990 610 {
lab=Do[26]}
N 3970 630 3990 630 {
lab=Do[27]}
N 3970 650 3990 650 {
lab=Do[28]}
N 3970 670 3990 670 {
lab=Do[29]}
N 3970 690 3990 690 {
lab=Do[30]}
N 3970 710 3990 710 {
lab=Do[31]}
N 3740 30 3740 50 {
lab=CLK_buf}
N 3760 30 3760 50 {
lab=SEL[23]}
N 3780 30 3780 50 {
lab=WE[0]}
N 3800 30 3800 50 {
lab=WE[1]}
N 3820 30 3820 50 {
lab=WE[2]}
N 3840 30 3840 50 {
lab=WE[3]}
N 3870 30 3870 50 {
lab=VDD}
N 3890 30 3890 50 {
lab=VSS}
N 3650 990 3670 990 {
lab=Di[0]}
N 3650 1010 3670 1010 {
lab=Di[1]}
N 3650 1030 3670 1030 {
lab=Di[2]}
N 3650 1050 3670 1050 {
lab=Di[3]}
N 3650 1070 3670 1070 {
lab=Di[4]}
N 3650 1090 3670 1090 {
lab=Di[5]}
N 3650 1110 3670 1110 {
lab=Di[6]}
N 3650 1130 3670 1130 {
lab=Di[7]}
N 3650 1150 3670 1150 {
lab=Di[8]}
N 3650 1170 3670 1170 {
lab=Di[9]}
N 3650 1190 3670 1190 {
lab=Di[10]}
N 3650 1210 3670 1210 {
lab=Di[11]}
N 3650 1230 3670 1230 {
lab=Di[12]}
N 3650 1250 3670 1250 {
lab=Di[13]}
N 3650 1270 3670 1270 {
lab=Di[14]}
N 3650 1290 3670 1290 {
lab=Di[15]}
N 3650 1310 3670 1310 {
lab=Di[16]}
N 3650 1330 3670 1330 {
lab=Di[17]}
N 3650 1350 3670 1350 {
lab=Di[18]}
N 3650 1370 3670 1370 {
lab=Di[19]}
N 3650 1390 3670 1390 {
lab=Di[20]}
N 3650 1410 3670 1410 {
lab=Di[21]}
N 3650 1430 3670 1430 {
lab=Di[22]}
N 3650 1450 3670 1450 {
lab=Di[23]}
N 3650 1470 3670 1470 {
lab=Di[24]}
N 3650 1490 3670 1490 {
lab=Di[25]}
N 3650 1510 3670 1510 {
lab=Di[26]}
N 3650 1530 3670 1530 {
lab=Di[27]}
N 3650 1550 3670 1550 {
lab=Di[28]}
N 3650 1570 3670 1570 {
lab=Di[29]}
N 3650 1590 3670 1590 {
lab=Di[30]}
N 3650 1610 3670 1610 {
lab=Di[31]}
N 3970 990 3990 990 {
lab=Do[0]}
N 3970 1010 3990 1010 {
lab=Do[1]}
N 3970 1030 3990 1030 {
lab=Do[2]}
N 3970 1050 3990 1050 {
lab=Do[3]}
N 3970 1070 3990 1070 {
lab=Do[4]}
N 3970 1090 3990 1090 {
lab=Do[5]}
N 3970 1110 3990 1110 {
lab=Do[6]}
N 3970 1130 3990 1130 {
lab=Do[7]}
N 3970 1150 3990 1150 {
lab=Do[8]}
N 3970 1170 3990 1170 {
lab=Do[9]}
N 3970 1190 3990 1190 {
lab=Do[10]}
N 3970 1210 3990 1210 {
lab=Do[11]}
N 3970 1230 3990 1230 {
lab=Do[12]}
N 3970 1250 3990 1250 {
lab=Do[13]}
N 3970 1270 3990 1270 {
lab=Do[14]}
N 3970 1290 3990 1290 {
lab=Do[15]}
N 3970 1310 3990 1310 {
lab=Do[16]}
N 3970 1330 3990 1330 {
lab=Do[17]}
N 3970 1350 3990 1350 {
lab=Do[18]}
N 3970 1370 3990 1370 {
lab=Do[19]}
N 3970 1390 3990 1390 {
lab=Do[20]}
N 3970 1410 3990 1410 {
lab=Do[21]}
N 3970 1430 3990 1430 {
lab=Do[22]}
N 3970 1450 3990 1450 {
lab=Do[23]}
N 3970 1470 3990 1470 {
lab=Do[24]}
N 3970 1490 3990 1490 {
lab=Do[25]}
N 3970 1510 3990 1510 {
lab=Do[26]}
N 3970 1530 3990 1530 {
lab=Do[27]}
N 3970 1550 3990 1550 {
lab=Do[28]}
N 3970 1570 3990 1570 {
lab=Do[29]}
N 3970 1590 3990 1590 {
lab=Do[30]}
N 3970 1610 3990 1610 {
lab=Do[31]}
N 3740 930 3740 950 {
lab=CLK_buf}
N 3760 930 3760 950 {
lab=SEL[31]}
N 3780 930 3780 950 {
lab=WE[0]}
N 3800 930 3800 950 {
lab=WE[1]}
N 3820 930 3820 950 {
lab=WE[2]}
N 3840 930 3840 950 {
lab=WE[3]}
N 3870 930 3870 950 {
lab=VDD}
N 3890 930 3890 950 {
lab=VSS}
N 3130 990 3150 990 {
lab=Di[0]}
N 3130 1010 3150 1010 {
lab=Di[1]}
N 3130 1030 3150 1030 {
lab=Di[2]}
N 3130 1050 3150 1050 {
lab=Di[3]}
N 3130 1070 3150 1070 {
lab=Di[4]}
N 3130 1090 3150 1090 {
lab=Di[5]}
N 3130 1110 3150 1110 {
lab=Di[6]}
N 3130 1130 3150 1130 {
lab=Di[7]}
N 3130 1150 3150 1150 {
lab=Di[8]}
N 3130 1170 3150 1170 {
lab=Di[9]}
N 3130 1190 3150 1190 {
lab=Di[10]}
N 3130 1210 3150 1210 {
lab=Di[11]}
N 3130 1230 3150 1230 {
lab=Di[12]}
N 3130 1250 3150 1250 {
lab=Di[13]}
N 3130 1270 3150 1270 {
lab=Di[14]}
N 3130 1290 3150 1290 {
lab=Di[15]}
N 3130 1310 3150 1310 {
lab=Di[16]}
N 3130 1330 3150 1330 {
lab=Di[17]}
N 3130 1350 3150 1350 {
lab=Di[18]}
N 3130 1370 3150 1370 {
lab=Di[19]}
N 3130 1390 3150 1390 {
lab=Di[20]}
N 3130 1410 3150 1410 {
lab=Di[21]}
N 3130 1430 3150 1430 {
lab=Di[22]}
N 3130 1450 3150 1450 {
lab=Di[23]}
N 3130 1470 3150 1470 {
lab=Di[24]}
N 3130 1490 3150 1490 {
lab=Di[25]}
N 3130 1510 3150 1510 {
lab=Di[26]}
N 3130 1530 3150 1530 {
lab=Di[27]}
N 3130 1550 3150 1550 {
lab=Di[28]}
N 3130 1570 3150 1570 {
lab=Di[29]}
N 3130 1590 3150 1590 {
lab=Di[30]}
N 3130 1610 3150 1610 {
lab=Di[31]}
N 3450 990 3470 990 {
lab=Do[0]}
N 3450 1010 3470 1010 {
lab=Do[1]}
N 3450 1030 3470 1030 {
lab=Do[2]}
N 3450 1050 3470 1050 {
lab=Do[3]}
N 3450 1070 3470 1070 {
lab=Do[4]}
N 3450 1090 3470 1090 {
lab=Do[5]}
N 3450 1110 3470 1110 {
lab=Do[6]}
N 3450 1130 3470 1130 {
lab=Do[7]}
N 3450 1150 3470 1150 {
lab=Do[8]}
N 3450 1170 3470 1170 {
lab=Do[9]}
N 3450 1190 3470 1190 {
lab=Do[10]}
N 3450 1210 3470 1210 {
lab=Do[11]}
N 3450 1230 3470 1230 {
lab=Do[12]}
N 3450 1250 3470 1250 {
lab=Do[13]}
N 3450 1270 3470 1270 {
lab=Do[14]}
N 3450 1290 3470 1290 {
lab=Do[15]}
N 3450 1310 3470 1310 {
lab=Do[16]}
N 3450 1330 3470 1330 {
lab=Do[17]}
N 3450 1350 3470 1350 {
lab=Do[18]}
N 3450 1370 3470 1370 {
lab=Do[19]}
N 3450 1390 3470 1390 {
lab=Do[20]}
N 3450 1410 3470 1410 {
lab=Do[21]}
N 3450 1430 3470 1430 {
lab=Do[22]}
N 3450 1450 3470 1450 {
lab=Do[23]}
N 3450 1470 3470 1470 {
lab=Do[24]}
N 3450 1490 3470 1490 {
lab=Do[25]}
N 3450 1510 3470 1510 {
lab=Do[26]}
N 3450 1530 3470 1530 {
lab=Do[27]}
N 3450 1550 3470 1550 {
lab=Do[28]}
N 3450 1570 3470 1570 {
lab=Do[29]}
N 3450 1590 3470 1590 {
lab=Do[30]}
N 3450 1610 3470 1610 {
lab=Do[31]}
N 3220 930 3220 950 {
lab=CLK_buf}
N 3240 930 3240 950 {
lab=SEL[30]}
N 3260 930 3260 950 {
lab=WE[0]}
N 3280 930 3280 950 {
lab=WE[1]}
N 3300 930 3300 950 {
lab=WE[2]}
N 3320 930 3320 950 {
lab=WE[3]}
N 3350 930 3350 950 {
lab=VDD}
N 3370 930 3370 950 {
lab=VSS}
N 2590 990 2610 990 {
lab=Di[0]}
N 2590 1010 2610 1010 {
lab=Di[1]}
N 2590 1030 2610 1030 {
lab=Di[2]}
N 2590 1050 2610 1050 {
lab=Di[3]}
N 2590 1070 2610 1070 {
lab=Di[4]}
N 2590 1090 2610 1090 {
lab=Di[5]}
N 2590 1110 2610 1110 {
lab=Di[6]}
N 2590 1130 2610 1130 {
lab=Di[7]}
N 2590 1150 2610 1150 {
lab=Di[8]}
N 2590 1170 2610 1170 {
lab=Di[9]}
N 2590 1190 2610 1190 {
lab=Di[10]}
N 2590 1210 2610 1210 {
lab=Di[11]}
N 2590 1230 2610 1230 {
lab=Di[12]}
N 2590 1250 2610 1250 {
lab=Di[13]}
N 2590 1270 2610 1270 {
lab=Di[14]}
N 2590 1290 2610 1290 {
lab=Di[15]}
N 2590 1310 2610 1310 {
lab=Di[16]}
N 2590 1330 2610 1330 {
lab=Di[17]}
N 2590 1350 2610 1350 {
lab=Di[18]}
N 2590 1370 2610 1370 {
lab=Di[19]}
N 2590 1390 2610 1390 {
lab=Di[20]}
N 2590 1410 2610 1410 {
lab=Di[21]}
N 2590 1430 2610 1430 {
lab=Di[22]}
N 2590 1450 2610 1450 {
lab=Di[23]}
N 2590 1470 2610 1470 {
lab=Di[24]}
N 2590 1490 2610 1490 {
lab=Di[25]}
N 2590 1510 2610 1510 {
lab=Di[26]}
N 2590 1530 2610 1530 {
lab=Di[27]}
N 2590 1550 2610 1550 {
lab=Di[28]}
N 2590 1570 2610 1570 {
lab=Di[29]}
N 2590 1590 2610 1590 {
lab=Di[30]}
N 2590 1610 2610 1610 {
lab=Di[31]}
N 2910 990 2930 990 {
lab=Do[0]}
N 2910 1010 2930 1010 {
lab=Do[1]}
N 2910 1030 2930 1030 {
lab=Do[2]}
N 2910 1050 2930 1050 {
lab=Do[3]}
N 2910 1070 2930 1070 {
lab=Do[4]}
N 2910 1090 2930 1090 {
lab=Do[5]}
N 2910 1110 2930 1110 {
lab=Do[6]}
N 2910 1130 2930 1130 {
lab=Do[7]}
N 2910 1150 2930 1150 {
lab=Do[8]}
N 2910 1170 2930 1170 {
lab=Do[9]}
N 2910 1190 2930 1190 {
lab=Do[10]}
N 2910 1210 2930 1210 {
lab=Do[11]}
N 2910 1230 2930 1230 {
lab=Do[12]}
N 2910 1250 2930 1250 {
lab=Do[13]}
N 2910 1270 2930 1270 {
lab=Do[14]}
N 2910 1290 2930 1290 {
lab=Do[15]}
N 2910 1310 2930 1310 {
lab=Do[16]}
N 2910 1330 2930 1330 {
lab=Do[17]}
N 2910 1350 2930 1350 {
lab=Do[18]}
N 2910 1370 2930 1370 {
lab=Do[19]}
N 2910 1390 2930 1390 {
lab=Do[20]}
N 2910 1410 2930 1410 {
lab=Do[21]}
N 2910 1430 2930 1430 {
lab=Do[22]}
N 2910 1450 2930 1450 {
lab=Do[23]}
N 2910 1470 2930 1470 {
lab=Do[24]}
N 2910 1490 2930 1490 {
lab=Do[25]}
N 2910 1510 2930 1510 {
lab=Do[26]}
N 2910 1530 2930 1530 {
lab=Do[27]}
N 2910 1550 2930 1550 {
lab=Do[28]}
N 2910 1570 2930 1570 {
lab=Do[29]}
N 2910 1590 2930 1590 {
lab=Do[30]}
N 2910 1610 2930 1610 {
lab=Do[31]}
N 2680 930 2680 950 {
lab=CLK_buf}
N 2700 930 2700 950 {
lab=SEL[29]}
N 2720 930 2720 950 {
lab=WE[0]}
N 2740 930 2740 950 {
lab=WE[1]}
N 2760 930 2760 950 {
lab=WE[2]}
N 2780 930 2780 950 {
lab=WE[3]}
N 2810 930 2810 950 {
lab=VDD}
N 2830 930 2830 950 {
lab=VSS}
N 2070 990 2090 990 {
lab=Di[0]}
N 2070 1010 2090 1010 {
lab=Di[1]}
N 2070 1030 2090 1030 {
lab=Di[2]}
N 2070 1050 2090 1050 {
lab=Di[3]}
N 2070 1070 2090 1070 {
lab=Di[4]}
N 2070 1090 2090 1090 {
lab=Di[5]}
N 2070 1110 2090 1110 {
lab=Di[6]}
N 2070 1130 2090 1130 {
lab=Di[7]}
N 2070 1150 2090 1150 {
lab=Di[8]}
N 2070 1170 2090 1170 {
lab=Di[9]}
N 2070 1190 2090 1190 {
lab=Di[10]}
N 2070 1210 2090 1210 {
lab=Di[11]}
N 2070 1230 2090 1230 {
lab=Di[12]}
N 2070 1250 2090 1250 {
lab=Di[13]}
N 2070 1270 2090 1270 {
lab=Di[14]}
N 2070 1290 2090 1290 {
lab=Di[15]}
N 2070 1310 2090 1310 {
lab=Di[16]}
N 2070 1330 2090 1330 {
lab=Di[17]}
N 2070 1350 2090 1350 {
lab=Di[18]}
N 2070 1370 2090 1370 {
lab=Di[19]}
N 2070 1390 2090 1390 {
lab=Di[20]}
N 2070 1410 2090 1410 {
lab=Di[21]}
N 2070 1430 2090 1430 {
lab=Di[22]}
N 2070 1450 2090 1450 {
lab=Di[23]}
N 2070 1470 2090 1470 {
lab=Di[24]}
N 2070 1490 2090 1490 {
lab=Di[25]}
N 2070 1510 2090 1510 {
lab=Di[26]}
N 2070 1530 2090 1530 {
lab=Di[27]}
N 2070 1550 2090 1550 {
lab=Di[28]}
N 2070 1570 2090 1570 {
lab=Di[29]}
N 2070 1590 2090 1590 {
lab=Di[30]}
N 2070 1610 2090 1610 {
lab=Di[31]}
N 2390 990 2410 990 {
lab=Do[0]}
N 2390 1010 2410 1010 {
lab=Do[1]}
N 2390 1030 2410 1030 {
lab=Do[2]}
N 2390 1050 2410 1050 {
lab=Do[3]}
N 2390 1070 2410 1070 {
lab=Do[4]}
N 2390 1090 2410 1090 {
lab=Do[5]}
N 2390 1110 2410 1110 {
lab=Do[6]}
N 2390 1130 2410 1130 {
lab=Do[7]}
N 2390 1150 2410 1150 {
lab=Do[8]}
N 2390 1170 2410 1170 {
lab=Do[9]}
N 2390 1190 2410 1190 {
lab=Do[10]}
N 2390 1210 2410 1210 {
lab=Do[11]}
N 2390 1230 2410 1230 {
lab=Do[12]}
N 2390 1250 2410 1250 {
lab=Do[13]}
N 2390 1270 2410 1270 {
lab=Do[14]}
N 2390 1290 2410 1290 {
lab=Do[15]}
N 2390 1310 2410 1310 {
lab=Do[16]}
N 2390 1330 2410 1330 {
lab=Do[17]}
N 2390 1350 2410 1350 {
lab=Do[18]}
N 2390 1370 2410 1370 {
lab=Do[19]}
N 2390 1390 2410 1390 {
lab=Do[20]}
N 2390 1410 2410 1410 {
lab=Do[21]}
N 2390 1430 2410 1430 {
lab=Do[22]}
N 2390 1450 2410 1450 {
lab=Do[23]}
N 2390 1470 2410 1470 {
lab=Do[24]}
N 2390 1490 2410 1490 {
lab=Do[25]}
N 2390 1510 2410 1510 {
lab=Do[26]}
N 2390 1530 2410 1530 {
lab=Do[27]}
N 2390 1550 2410 1550 {
lab=Do[28]}
N 2390 1570 2410 1570 {
lab=Do[29]}
N 2390 1590 2410 1590 {
lab=Do[30]}
N 2390 1610 2410 1610 {
lab=Do[31]}
N 2160 930 2160 950 {
lab=CLK_buf}
N 2180 930 2180 950 {
lab=SEL[28]}
N 2200 930 2200 950 {
lab=WE[0]}
N 2220 930 2220 950 {
lab=WE[1]}
N 2240 930 2240 950 {
lab=WE[2]}
N 2260 930 2260 950 {
lab=WE[3]}
N 2290 930 2290 950 {
lab=VDD}
N 2310 930 2310 950 {
lab=VSS}
N 1550 990 1570 990 {
lab=Di[0]}
N 1550 1010 1570 1010 {
lab=Di[1]}
N 1550 1030 1570 1030 {
lab=Di[2]}
N 1550 1050 1570 1050 {
lab=Di[3]}
N 1550 1070 1570 1070 {
lab=Di[4]}
N 1550 1090 1570 1090 {
lab=Di[5]}
N 1550 1110 1570 1110 {
lab=Di[6]}
N 1550 1130 1570 1130 {
lab=Di[7]}
N 1550 1150 1570 1150 {
lab=Di[8]}
N 1550 1170 1570 1170 {
lab=Di[9]}
N 1550 1190 1570 1190 {
lab=Di[10]}
N 1550 1210 1570 1210 {
lab=Di[11]}
N 1550 1230 1570 1230 {
lab=Di[12]}
N 1550 1250 1570 1250 {
lab=Di[13]}
N 1550 1270 1570 1270 {
lab=Di[14]}
N 1550 1290 1570 1290 {
lab=Di[15]}
N 1550 1310 1570 1310 {
lab=Di[16]}
N 1550 1330 1570 1330 {
lab=Di[17]}
N 1550 1350 1570 1350 {
lab=Di[18]}
N 1550 1370 1570 1370 {
lab=Di[19]}
N 1550 1390 1570 1390 {
lab=Di[20]}
N 1550 1410 1570 1410 {
lab=Di[21]}
N 1550 1430 1570 1430 {
lab=Di[22]}
N 1550 1450 1570 1450 {
lab=Di[23]}
N 1550 1470 1570 1470 {
lab=Di[24]}
N 1550 1490 1570 1490 {
lab=Di[25]}
N 1550 1510 1570 1510 {
lab=Di[26]}
N 1550 1530 1570 1530 {
lab=Di[27]}
N 1550 1550 1570 1550 {
lab=Di[28]}
N 1550 1570 1570 1570 {
lab=Di[29]}
N 1550 1590 1570 1590 {
lab=Di[30]}
N 1550 1610 1570 1610 {
lab=Di[31]}
N 1870 990 1890 990 {
lab=Do[0]}
N 1870 1010 1890 1010 {
lab=Do[1]}
N 1870 1030 1890 1030 {
lab=Do[2]}
N 1870 1050 1890 1050 {
lab=Do[3]}
N 1870 1070 1890 1070 {
lab=Do[4]}
N 1870 1090 1890 1090 {
lab=Do[5]}
N 1870 1110 1890 1110 {
lab=Do[6]}
N 1870 1130 1890 1130 {
lab=Do[7]}
N 1870 1150 1890 1150 {
lab=Do[8]}
N 1870 1170 1890 1170 {
lab=Do[9]}
N 1870 1190 1890 1190 {
lab=Do[10]}
N 1870 1210 1890 1210 {
lab=Do[11]}
N 1870 1230 1890 1230 {
lab=Do[12]}
N 1870 1250 1890 1250 {
lab=Do[13]}
N 1870 1270 1890 1270 {
lab=Do[14]}
N 1870 1290 1890 1290 {
lab=Do[15]}
N 1870 1310 1890 1310 {
lab=Do[16]}
N 1870 1330 1890 1330 {
lab=Do[17]}
N 1870 1350 1890 1350 {
lab=Do[18]}
N 1870 1370 1890 1370 {
lab=Do[19]}
N 1870 1390 1890 1390 {
lab=Do[20]}
N 1870 1410 1890 1410 {
lab=Do[21]}
N 1870 1430 1890 1430 {
lab=Do[22]}
N 1870 1450 1890 1450 {
lab=Do[23]}
N 1870 1470 1890 1470 {
lab=Do[24]}
N 1870 1490 1890 1490 {
lab=Do[25]}
N 1870 1510 1890 1510 {
lab=Do[26]}
N 1870 1530 1890 1530 {
lab=Do[27]}
N 1870 1550 1890 1550 {
lab=Do[28]}
N 1870 1570 1890 1570 {
lab=Do[29]}
N 1870 1590 1890 1590 {
lab=Do[30]}
N 1870 1610 1890 1610 {
lab=Do[31]}
N 1640 930 1640 950 {
lab=CLK_buf}
N 1660 930 1660 950 {
lab=SEL[27]}
N 1680 930 1680 950 {
lab=WE[0]}
N 1700 930 1700 950 {
lab=WE[1]}
N 1720 930 1720 950 {
lab=WE[2]}
N 1740 930 1740 950 {
lab=WE[3]}
N 1770 930 1770 950 {
lab=VDD}
N 1790 930 1790 950 {
lab=VSS}
N 1030 990 1050 990 {
lab=Di[0]}
N 1030 1010 1050 1010 {
lab=Di[1]}
N 1030 1030 1050 1030 {
lab=Di[2]}
N 1030 1050 1050 1050 {
lab=Di[3]}
N 1030 1070 1050 1070 {
lab=Di[4]}
N 1030 1090 1050 1090 {
lab=Di[5]}
N 1030 1110 1050 1110 {
lab=Di[6]}
N 1030 1130 1050 1130 {
lab=Di[7]}
N 1030 1150 1050 1150 {
lab=Di[8]}
N 1030 1170 1050 1170 {
lab=Di[9]}
N 1030 1190 1050 1190 {
lab=Di[10]}
N 1030 1210 1050 1210 {
lab=Di[11]}
N 1030 1230 1050 1230 {
lab=Di[12]}
N 1030 1250 1050 1250 {
lab=Di[13]}
N 1030 1270 1050 1270 {
lab=Di[14]}
N 1030 1290 1050 1290 {
lab=Di[15]}
N 1030 1310 1050 1310 {
lab=Di[16]}
N 1030 1330 1050 1330 {
lab=Di[17]}
N 1030 1350 1050 1350 {
lab=Di[18]}
N 1030 1370 1050 1370 {
lab=Di[19]}
N 1030 1390 1050 1390 {
lab=Di[20]}
N 1030 1410 1050 1410 {
lab=Di[21]}
N 1030 1430 1050 1430 {
lab=Di[22]}
N 1030 1450 1050 1450 {
lab=Di[23]}
N 1030 1470 1050 1470 {
lab=Di[24]}
N 1030 1490 1050 1490 {
lab=Di[25]}
N 1030 1510 1050 1510 {
lab=Di[26]}
N 1030 1530 1050 1530 {
lab=Di[27]}
N 1030 1550 1050 1550 {
lab=Di[28]}
N 1030 1570 1050 1570 {
lab=Di[29]}
N 1030 1590 1050 1590 {
lab=Di[30]}
N 1030 1610 1050 1610 {
lab=Di[31]}
N 1350 990 1370 990 {
lab=Do[0]}
N 1350 1010 1370 1010 {
lab=Do[1]}
N 1350 1030 1370 1030 {
lab=Do[2]}
N 1350 1050 1370 1050 {
lab=Do[3]}
N 1350 1070 1370 1070 {
lab=Do[4]}
N 1350 1090 1370 1090 {
lab=Do[5]}
N 1350 1110 1370 1110 {
lab=Do[6]}
N 1350 1130 1370 1130 {
lab=Do[7]}
N 1350 1150 1370 1150 {
lab=Do[8]}
N 1350 1170 1370 1170 {
lab=Do[9]}
N 1350 1190 1370 1190 {
lab=Do[10]}
N 1350 1210 1370 1210 {
lab=Do[11]}
N 1350 1230 1370 1230 {
lab=Do[12]}
N 1350 1250 1370 1250 {
lab=Do[13]}
N 1350 1270 1370 1270 {
lab=Do[14]}
N 1350 1290 1370 1290 {
lab=Do[15]}
N 1350 1310 1370 1310 {
lab=Do[16]}
N 1350 1330 1370 1330 {
lab=Do[17]}
N 1350 1350 1370 1350 {
lab=Do[18]}
N 1350 1370 1370 1370 {
lab=Do[19]}
N 1350 1390 1370 1390 {
lab=Do[20]}
N 1350 1410 1370 1410 {
lab=Do[21]}
N 1350 1430 1370 1430 {
lab=Do[22]}
N 1350 1450 1370 1450 {
lab=Do[23]}
N 1350 1470 1370 1470 {
lab=Do[24]}
N 1350 1490 1370 1490 {
lab=Do[25]}
N 1350 1510 1370 1510 {
lab=Do[26]}
N 1350 1530 1370 1530 {
lab=Do[27]}
N 1350 1550 1370 1550 {
lab=Do[28]}
N 1350 1570 1370 1570 {
lab=Do[29]}
N 1350 1590 1370 1590 {
lab=Do[30]}
N 1350 1610 1370 1610 {
lab=Do[31]}
N 1120 930 1120 950 {
lab=CLK_buf}
N 1140 930 1140 950 {
lab=SEL[26]}
N 1160 930 1160 950 {
lab=WE[0]}
N 1180 930 1180 950 {
lab=WE[1]}
N 1200 930 1200 950 {
lab=WE[2]}
N 1220 930 1220 950 {
lab=WE[3]}
N 1250 930 1250 950 {
lab=VDD}
N 1270 930 1270 950 {
lab=VSS}
N 490 990 510 990 {
lab=Di[0]}
N 490 1010 510 1010 {
lab=Di[1]}
N 490 1030 510 1030 {
lab=Di[2]}
N 490 1050 510 1050 {
lab=Di[3]}
N 490 1070 510 1070 {
lab=Di[4]}
N 490 1090 510 1090 {
lab=Di[5]}
N 490 1110 510 1110 {
lab=Di[6]}
N 490 1130 510 1130 {
lab=Di[7]}
N 490 1150 510 1150 {
lab=Di[8]}
N 490 1170 510 1170 {
lab=Di[9]}
N 490 1190 510 1190 {
lab=Di[10]}
N 490 1210 510 1210 {
lab=Di[11]}
N 490 1230 510 1230 {
lab=Di[12]}
N 490 1250 510 1250 {
lab=Di[13]}
N 490 1270 510 1270 {
lab=Di[14]}
N 490 1290 510 1290 {
lab=Di[15]}
N 490 1310 510 1310 {
lab=Di[16]}
N 490 1330 510 1330 {
lab=Di[17]}
N 490 1350 510 1350 {
lab=Di[18]}
N 490 1370 510 1370 {
lab=Di[19]}
N 490 1390 510 1390 {
lab=Di[20]}
N 490 1410 510 1410 {
lab=Di[21]}
N 490 1430 510 1430 {
lab=Di[22]}
N 490 1450 510 1450 {
lab=Di[23]}
N 490 1470 510 1470 {
lab=Di[24]}
N 490 1490 510 1490 {
lab=Di[25]}
N 490 1510 510 1510 {
lab=Di[26]}
N 490 1530 510 1530 {
lab=Di[27]}
N 490 1550 510 1550 {
lab=Di[28]}
N 490 1570 510 1570 {
lab=Di[29]}
N 490 1590 510 1590 {
lab=Di[30]}
N 490 1610 510 1610 {
lab=Di[31]}
N 810 990 830 990 {
lab=Do[0]}
N 810 1010 830 1010 {
lab=Do[1]}
N 810 1030 830 1030 {
lab=Do[2]}
N 810 1050 830 1050 {
lab=Do[3]}
N 810 1070 830 1070 {
lab=Do[4]}
N 810 1090 830 1090 {
lab=Do[5]}
N 810 1110 830 1110 {
lab=Do[6]}
N 810 1130 830 1130 {
lab=Do[7]}
N 810 1150 830 1150 {
lab=Do[8]}
N 810 1170 830 1170 {
lab=Do[9]}
N 810 1190 830 1190 {
lab=Do[10]}
N 810 1210 830 1210 {
lab=Do[11]}
N 810 1230 830 1230 {
lab=Do[12]}
N 810 1250 830 1250 {
lab=Do[13]}
N 810 1270 830 1270 {
lab=Do[14]}
N 810 1290 830 1290 {
lab=Do[15]}
N 810 1310 830 1310 {
lab=Do[16]}
N 810 1330 830 1330 {
lab=Do[17]}
N 810 1350 830 1350 {
lab=Do[18]}
N 810 1370 830 1370 {
lab=Do[19]}
N 810 1390 830 1390 {
lab=Do[20]}
N 810 1410 830 1410 {
lab=Do[21]}
N 810 1430 830 1430 {
lab=Do[22]}
N 810 1450 830 1450 {
lab=Do[23]}
N 810 1470 830 1470 {
lab=Do[24]}
N 810 1490 830 1490 {
lab=Do[25]}
N 810 1510 830 1510 {
lab=Do[26]}
N 810 1530 830 1530 {
lab=Do[27]}
N 810 1550 830 1550 {
lab=Do[28]}
N 810 1570 830 1570 {
lab=Do[29]}
N 810 1590 830 1590 {
lab=Do[30]}
N 810 1610 830 1610 {
lab=Do[31]}
N 580 930 580 950 {
lab=CLK_buf}
N 600 930 600 950 {
lab=SEL[25]}
N 620 930 620 950 {
lab=WE[0]}
N 640 930 640 950 {
lab=WE[1]}
N 660 930 660 950 {
lab=WE[2]}
N 680 930 680 950 {
lab=WE[3]}
N 710 930 710 950 {
lab=VDD}
N 730 930 730 950 {
lab=VSS}
N -30 990 -10 990 {
lab=Di[0]}
N -30 1010 -10 1010 {
lab=Di[1]}
N -30 1030 -10 1030 {
lab=Di[2]}
N -30 1050 -10 1050 {
lab=Di[3]}
N -30 1070 -10 1070 {
lab=Di[4]}
N -30 1090 -10 1090 {
lab=Di[5]}
N -30 1110 -10 1110 {
lab=Di[6]}
N -30 1130 -10 1130 {
lab=Di[7]}
N -30 1150 -10 1150 {
lab=Di[8]}
N -30 1170 -10 1170 {
lab=Di[9]}
N -30 1190 -10 1190 {
lab=Di[10]}
N -30 1210 -10 1210 {
lab=Di[11]}
N -30 1230 -10 1230 {
lab=Di[12]}
N -30 1250 -10 1250 {
lab=Di[13]}
N -30 1270 -10 1270 {
lab=Di[14]}
N -30 1290 -10 1290 {
lab=Di[15]}
N -30 1310 -10 1310 {
lab=Di[16]}
N -30 1330 -10 1330 {
lab=Di[17]}
N -30 1350 -10 1350 {
lab=Di[18]}
N -30 1370 -10 1370 {
lab=Di[19]}
N -30 1390 -10 1390 {
lab=Di[20]}
N -30 1410 -10 1410 {
lab=Di[21]}
N -30 1430 -10 1430 {
lab=Di[22]}
N -30 1450 -10 1450 {
lab=Di[23]}
N -30 1470 -10 1470 {
lab=Di[24]}
N -30 1490 -10 1490 {
lab=Di[25]}
N -30 1510 -10 1510 {
lab=Di[26]}
N -30 1530 -10 1530 {
lab=Di[27]}
N -30 1550 -10 1550 {
lab=Di[28]}
N -30 1570 -10 1570 {
lab=Di[29]}
N -30 1590 -10 1590 {
lab=Di[30]}
N -30 1610 -10 1610 {
lab=Di[31]}
N 290 990 310 990 {
lab=Do[0]}
N 290 1010 310 1010 {
lab=Do[1]}
N 290 1030 310 1030 {
lab=Do[2]}
N 290 1050 310 1050 {
lab=Do[3]}
N 290 1070 310 1070 {
lab=Do[4]}
N 290 1090 310 1090 {
lab=Do[5]}
N 290 1110 310 1110 {
lab=Do[6]}
N 290 1130 310 1130 {
lab=Do[7]}
N 290 1150 310 1150 {
lab=Do[8]}
N 290 1170 310 1170 {
lab=Do[9]}
N 290 1190 310 1190 {
lab=Do[10]}
N 290 1210 310 1210 {
lab=Do[11]}
N 290 1230 310 1230 {
lab=Do[12]}
N 290 1250 310 1250 {
lab=Do[13]}
N 290 1270 310 1270 {
lab=Do[14]}
N 290 1290 310 1290 {
lab=Do[15]}
N 290 1310 310 1310 {
lab=Do[16]}
N 290 1330 310 1330 {
lab=Do[17]}
N 290 1350 310 1350 {
lab=Do[18]}
N 290 1370 310 1370 {
lab=Do[19]}
N 290 1390 310 1390 {
lab=Do[20]}
N 290 1410 310 1410 {
lab=Do[21]}
N 290 1430 310 1430 {
lab=Do[22]}
N 290 1450 310 1450 {
lab=Do[23]}
N 290 1470 310 1470 {
lab=Do[24]}
N 290 1490 310 1490 {
lab=Do[25]}
N 290 1510 310 1510 {
lab=Do[26]}
N 290 1530 310 1530 {
lab=Do[27]}
N 290 1550 310 1550 {
lab=Do[28]}
N 290 1570 310 1570 {
lab=Do[29]}
N 290 1590 310 1590 {
lab=Do[30]}
N 290 1610 310 1610 {
lab=Do[31]}
N 60 930 60 950 {
lab=CLK_buf}
N 80 930 80 950 {
lab=SEL[24]}
N 100 930 100 950 {
lab=WE[0]}
N 120 930 120 950 {
lab=WE[1]}
N 140 930 140 950 {
lab=WE[2]}
N 160 930 160 950 {
lab=WE[3]}
N 190 930 190 950 {
lab=VDD}
N 210 930 210 950 {
lab=VSS}
N -1710 -2040 -1710 -2030 {}
N -1710 -1950 -1710 -1940 {}
N -1550 -2040 -1550 -2030 {}
N -1550 -1950 -1550 -1940 {}
N -1300 -1990 -1280 -1990 {
lab=#net37}
N -1450 -1990 -1440 -1990 {
lab=CLK}
N -1380 -2040 -1380 -2030 {}
N -1380 -1950 -1380 -1940 {}
N -1220 -2040 -1220 -2030 {}
N -1220 -1950 -1220 -1940 {}
N -1960 -1990 -1940 -1990 {
lab=#net37}
N -1800 -1990 -1780 -1990 {
lab=CLK_buf}
N -2110 -1990 -2100 -1990 {
lab=CLK}
N -2040 -2040 -2040 -2030 {}
N -2040 -1950 -2040 -1940 {}
N -1880 -2040 -1880 -2030 {}
N -1880 -1950 -1880 -1940 {}
N -1140 -1990 -1120 -1990 {lab=CLK_buf}
C {xschem_lib/word.sym} 130 -1510 0 0 {name=xbyte1 NF=2}
C {lab_wire.sym} -40 -1760 0 0 {name=l1 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} -40 -1740 0 0 {name=l2 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} -40 -1720 0 0 {name=l3 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} -40 -1700 0 0 {name=l4 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} -40 -1680 0 0 {name=l5 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} -40 -1660 0 0 {name=l6 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} -40 -1640 0 0 {name=l7 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} -40 -1620 0 0 {name=l8 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} -40 -1600 0 0 {name=l9 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} -40 -1580 0 0 {name=l10 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} -40 -1560 0 0 {name=l11 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} -40 -1540 0 0 {name=l12 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} -40 -1520 0 0 {name=l13 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} -40 -1500 0 0 {name=l14 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} -40 -1480 0 0 {name=l15 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} -40 -1460 0 0 {name=l16 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} -40 -1440 0 0 {name=l17 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} -40 -1420 0 0 {name=l18 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} -40 -1400 0 0 {name=l19 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} -40 -1380 0 0 {name=l20 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} -40 -1360 0 0 {name=l21 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} -40 -1340 0 0 {name=l22 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} -40 -1320 0 0 {name=l23 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} -40 -1300 0 0 {name=l24 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} -40 -1280 0 0 {name=l25 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} -40 -1260 0 0 {name=l26 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} -40 -1240 0 0 {name=l27 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} -40 -1220 0 0 {name=l28 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} -40 -1200 0 0 {name=l29 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} -40 -1180 0 0 {name=l30 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} -40 -1140 0 0 {name=l31 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} -40 -1160 0 0 {name=l32 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 300 -1760 2 0 {name=l33 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 300 -1740 2 0 {name=l34 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 300 -1720 2 0 {name=l35 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 300 -1700 2 0 {name=l36 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 300 -1680 2 0 {name=l37 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 300 -1660 2 0 {name=l38 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 300 -1640 2 0 {name=l39 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 300 -1620 2 0 {name=l40 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 300 -1600 2 0 {name=l41 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 300 -1580 2 0 {name=l42 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 300 -1560 2 0 {name=l43 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 300 -1540 2 0 {name=l44 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 300 -1520 2 0 {name=l45 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 300 -1500 2 0 {name=l46 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 300 -1480 2 0 {name=l47 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 300 -1460 2 0 {name=l48 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 300 -1440 2 0 {name=l49 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 300 -1420 2 0 {name=l50 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 300 -1400 2 0 {name=l51 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 300 -1380 2 0 {name=l52 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 300 -1360 2 0 {name=l53 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 300 -1340 2 0 {name=l54 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 300 -1320 2 0 {name=l55 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 300 -1300 2 0 {name=l56 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 300 -1280 2 0 {name=l57 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 300 -1260 2 0 {name=l58 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 300 -1240 2 0 {name=l59 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 300 -1220 2 0 {name=l60 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 300 -1200 2 0 {name=l61 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 300 -1180 2 0 {name=l62 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 300 -1160 2 0 {name=l63 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 300 -1140 2 0 {name=l64 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 50 -1820 0 0 {name=l65 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 90 -1820 1 0 {name=l66 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 110 -1820 1 0 {name=l67 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 130 -1820 1 0 {name=l68 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 150 -1820 1 0 {name=l69 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 180 -1820 1 0 {name=l70 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 200 -1820 1 0 {name=l71 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 650 -1510 0 0 {name=xbyte2 NF=2}
C {lab_wire.sym} 480 -1760 0 0 {name=l72 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 480 -1740 0 0 {name=l73 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 480 -1720 0 0 {name=l74 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 480 -1700 0 0 {name=l75 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 480 -1680 0 0 {name=l76 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 480 -1660 0 0 {name=l77 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 480 -1640 0 0 {name=l78 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 480 -1620 0 0 {name=l79 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 480 -1600 0 0 {name=l80 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 480 -1580 0 0 {name=l81 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 480 -1560 0 0 {name=l82 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 480 -1540 0 0 {name=l83 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 480 -1520 0 0 {name=l84 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 480 -1500 0 0 {name=l85 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 480 -1480 0 0 {name=l86 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 480 -1460 0 0 {name=l87 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 480 -1440 0 0 {name=l88 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 480 -1420 0 0 {name=l89 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 480 -1400 0 0 {name=l90 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 480 -1380 0 0 {name=l91 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 480 -1360 0 0 {name=l92 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 480 -1340 0 0 {name=l93 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 480 -1320 0 0 {name=l94 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 480 -1300 0 0 {name=l95 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 480 -1280 0 0 {name=l96 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 480 -1260 0 0 {name=l97 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 480 -1240 0 0 {name=l98 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 480 -1220 0 0 {name=l99 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 480 -1200 0 0 {name=l100 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 480 -1180 0 0 {name=l101 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 480 -1140 0 0 {name=l102 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 480 -1160 0 0 {name=l103 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 820 -1760 2 0 {name=l104 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 820 -1740 2 0 {name=l105 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 820 -1720 2 0 {name=l106 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 820 -1700 2 0 {name=l107 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 820 -1680 2 0 {name=l108 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 820 -1660 2 0 {name=l109 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 820 -1640 2 0 {name=l110 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 820 -1620 2 0 {name=l111 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 820 -1600 2 0 {name=l112 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 820 -1580 2 0 {name=l113 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 820 -1560 2 0 {name=l114 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 820 -1540 2 0 {name=l115 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 820 -1520 2 0 {name=l116 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 820 -1500 2 0 {name=l117 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 820 -1480 2 0 {name=l118 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 820 -1460 2 0 {name=l119 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 820 -1440 2 0 {name=l120 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 820 -1420 2 0 {name=l121 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 820 -1400 2 0 {name=l122 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 820 -1380 2 0 {name=l123 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 820 -1360 2 0 {name=l124 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 820 -1340 2 0 {name=l125 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 820 -1320 2 0 {name=l126 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 820 -1300 2 0 {name=l127 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 820 -1280 2 0 {name=l128 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 820 -1260 2 0 {name=l129 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 820 -1240 2 0 {name=l130 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 820 -1220 2 0 {name=l131 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 820 -1200 2 0 {name=l132 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 820 -1180 2 0 {name=l133 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 820 -1160 2 0 {name=l134 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 820 -1140 2 0 {name=l135 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 570 -1820 0 0 {name=l136 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 610 -1820 1 0 {name=l137 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 630 -1820 1 0 {name=l138 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 650 -1820 1 0 {name=l139 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 670 -1820 1 0 {name=l140 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 700 -1820 1 0 {name=l141 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 720 -1820 1 0 {name=l142 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 1190 -1510 0 0 {name=xbyte3 NF=2}
C {lab_wire.sym} 1020 -1760 0 0 {name=l143 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1020 -1740 0 0 {name=l144 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1020 -1720 0 0 {name=l145 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1020 -1700 0 0 {name=l146 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1020 -1680 0 0 {name=l147 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1020 -1660 0 0 {name=l148 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1020 -1640 0 0 {name=l149 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1020 -1620 0 0 {name=l150 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1020 -1600 0 0 {name=l151 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1020 -1580 0 0 {name=l152 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1020 -1560 0 0 {name=l153 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1020 -1540 0 0 {name=l154 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1020 -1520 0 0 {name=l155 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1020 -1500 0 0 {name=l156 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1020 -1480 0 0 {name=l157 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1020 -1460 0 0 {name=l158 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1020 -1440 0 0 {name=l159 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1020 -1420 0 0 {name=l160 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1020 -1400 0 0 {name=l161 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1020 -1380 0 0 {name=l162 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1020 -1360 0 0 {name=l163 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1020 -1340 0 0 {name=l164 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1020 -1320 0 0 {name=l165 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1020 -1300 0 0 {name=l166 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1020 -1280 0 0 {name=l167 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1020 -1260 0 0 {name=l168 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1020 -1240 0 0 {name=l169 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1020 -1220 0 0 {name=l170 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1020 -1200 0 0 {name=l171 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1020 -1180 0 0 {name=l172 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1020 -1140 0 0 {name=l173 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1020 -1160 0 0 {name=l174 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1360 -1760 2 0 {name=l175 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1360 -1740 2 0 {name=l176 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1360 -1720 2 0 {name=l177 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1360 -1700 2 0 {name=l178 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1360 -1680 2 0 {name=l179 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1360 -1660 2 0 {name=l180 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1360 -1640 2 0 {name=l181 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1360 -1620 2 0 {name=l182 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1360 -1600 2 0 {name=l183 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1360 -1580 2 0 {name=l184 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1360 -1560 2 0 {name=l185 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1360 -1540 2 0 {name=l186 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1360 -1520 2 0 {name=l187 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1360 -1500 2 0 {name=l188 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1360 -1480 2 0 {name=l189 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1360 -1460 2 0 {name=l190 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1360 -1440 2 0 {name=l191 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1360 -1420 2 0 {name=l192 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1360 -1400 2 0 {name=l193 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1360 -1380 2 0 {name=l194 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1360 -1360 2 0 {name=l195 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1360 -1340 2 0 {name=l196 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1360 -1320 2 0 {name=l197 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1360 -1300 2 0 {name=l198 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1360 -1280 2 0 {name=l199 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1360 -1260 2 0 {name=l200 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1360 -1240 2 0 {name=l201 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1360 -1220 2 0 {name=l202 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1360 -1200 2 0 {name=l203 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1360 -1180 2 0 {name=l204 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1360 -1160 2 0 {name=l205 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1360 -1140 2 0 {name=l206 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1110 -1820 0 0 {name=l207 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1150 -1820 1 0 {name=l208 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1170 -1820 1 0 {name=l209 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1190 -1820 1 0 {name=l210 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1210 -1820 1 0 {name=l211 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1240 -1820 1 0 {name=l212 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1260 -1820 1 0 {name=l213 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 1710 -1510 0 0 {name=xbyte4 NF=2}
C {lab_wire.sym} 1540 -1760 0 0 {name=l214 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1540 -1740 0 0 {name=l215 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1540 -1720 0 0 {name=l216 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1540 -1700 0 0 {name=l217 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1540 -1680 0 0 {name=l218 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1540 -1660 0 0 {name=l219 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1540 -1640 0 0 {name=l220 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1540 -1620 0 0 {name=l221 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1540 -1600 0 0 {name=l222 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1540 -1580 0 0 {name=l223 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1540 -1560 0 0 {name=l224 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1540 -1540 0 0 {name=l225 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1540 -1520 0 0 {name=l226 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1540 -1500 0 0 {name=l227 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1540 -1480 0 0 {name=l228 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1540 -1460 0 0 {name=l229 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1540 -1440 0 0 {name=l230 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1540 -1420 0 0 {name=l231 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1540 -1400 0 0 {name=l232 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1540 -1380 0 0 {name=l233 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1540 -1360 0 0 {name=l234 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1540 -1340 0 0 {name=l235 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1540 -1320 0 0 {name=l236 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1540 -1300 0 0 {name=l237 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1540 -1280 0 0 {name=l238 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1540 -1260 0 0 {name=l239 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1540 -1240 0 0 {name=l240 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1540 -1220 0 0 {name=l241 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1540 -1200 0 0 {name=l242 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1540 -1180 0 0 {name=l243 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1540 -1140 0 0 {name=l244 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1540 -1160 0 0 {name=l245 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1880 -1760 2 0 {name=l246 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1880 -1740 2 0 {name=l247 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1880 -1720 2 0 {name=l248 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1880 -1700 2 0 {name=l249 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1880 -1680 2 0 {name=l250 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1880 -1660 2 0 {name=l251 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1880 -1640 2 0 {name=l252 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1880 -1620 2 0 {name=l253 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1880 -1600 2 0 {name=l254 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1880 -1580 2 0 {name=l255 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1880 -1560 2 0 {name=l256 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1880 -1540 2 0 {name=l257 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1880 -1520 2 0 {name=l258 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1880 -1500 2 0 {name=l259 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1880 -1480 2 0 {name=l260 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1880 -1460 2 0 {name=l261 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1880 -1440 2 0 {name=l262 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1880 -1420 2 0 {name=l263 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1880 -1400 2 0 {name=l264 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1880 -1380 2 0 {name=l265 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1880 -1360 2 0 {name=l266 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1880 -1340 2 0 {name=l267 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1880 -1320 2 0 {name=l268 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1880 -1300 2 0 {name=l269 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1880 -1280 2 0 {name=l270 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1880 -1260 2 0 {name=l271 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1880 -1240 2 0 {name=l272 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1880 -1220 2 0 {name=l273 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1880 -1200 2 0 {name=l274 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1880 -1180 2 0 {name=l275 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1880 -1160 2 0 {name=l276 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1880 -1140 2 0 {name=l277 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1630 -1820 0 0 {name=l278 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1670 -1820 1 0 {name=l279 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1690 -1820 1 0 {name=l280 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1710 -1820 1 0 {name=l281 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1730 -1820 1 0 {name=l282 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1760 -1820 1 0 {name=l283 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1780 -1820 1 0 {name=l284 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 2230 -1510 0 0 {name=xbyte5 NF=2}
C {lab_wire.sym} 2060 -1760 0 0 {name=l285 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2060 -1740 0 0 {name=l286 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2060 -1720 0 0 {name=l287 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2060 -1700 0 0 {name=l288 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2060 -1680 0 0 {name=l289 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2060 -1660 0 0 {name=l290 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2060 -1640 0 0 {name=l291 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2060 -1620 0 0 {name=l292 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2060 -1600 0 0 {name=l293 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2060 -1580 0 0 {name=l294 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2060 -1560 0 0 {name=l295 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2060 -1540 0 0 {name=l296 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2060 -1520 0 0 {name=l297 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2060 -1500 0 0 {name=l298 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2060 -1480 0 0 {name=l299 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2060 -1460 0 0 {name=l300 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2060 -1440 0 0 {name=l301 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2060 -1420 0 0 {name=l302 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2060 -1400 0 0 {name=l303 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2060 -1380 0 0 {name=l304 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2060 -1360 0 0 {name=l305 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2060 -1340 0 0 {name=l306 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2060 -1320 0 0 {name=l307 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2060 -1300 0 0 {name=l308 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2060 -1280 0 0 {name=l309 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2060 -1260 0 0 {name=l310 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2060 -1240 0 0 {name=l311 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2060 -1220 0 0 {name=l312 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2060 -1200 0 0 {name=l313 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2060 -1180 0 0 {name=l314 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2060 -1140 0 0 {name=l315 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2060 -1160 0 0 {name=l316 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2400 -1760 2 0 {name=l317 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2400 -1740 2 0 {name=l318 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2400 -1720 2 0 {name=l319 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2400 -1700 2 0 {name=l320 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2400 -1680 2 0 {name=l321 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2400 -1660 2 0 {name=l322 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2400 -1640 2 0 {name=l323 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2400 -1620 2 0 {name=l324 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2400 -1600 2 0 {name=l325 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2400 -1580 2 0 {name=l326 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2400 -1560 2 0 {name=l327 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2400 -1540 2 0 {name=l328 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2400 -1520 2 0 {name=l329 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2400 -1500 2 0 {name=l330 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2400 -1480 2 0 {name=l331 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2400 -1460 2 0 {name=l332 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2400 -1440 2 0 {name=l333 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2400 -1420 2 0 {name=l334 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2400 -1400 2 0 {name=l335 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2400 -1380 2 0 {name=l336 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2400 -1360 2 0 {name=l337 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2400 -1340 2 0 {name=l338 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2400 -1320 2 0 {name=l339 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2400 -1300 2 0 {name=l340 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2400 -1280 2 0 {name=l341 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2400 -1260 2 0 {name=l342 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2400 -1240 2 0 {name=l343 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2400 -1220 2 0 {name=l344 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2400 -1200 2 0 {name=l345 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2400 -1180 2 0 {name=l346 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2400 -1160 2 0 {name=l347 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2400 -1140 2 0 {name=l348 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2150 -1820 0 0 {name=l349 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2190 -1820 1 0 {name=l350 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2210 -1820 1 0 {name=l351 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2230 -1820 1 0 {name=l352 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2250 -1820 1 0 {name=l353 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2280 -1820 1 0 {name=l354 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2300 -1820 1 0 {name=l355 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 2750 -1510 0 0 {name=xbyte6 NF=2}
C {lab_wire.sym} 2580 -1760 0 0 {name=l356 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2580 -1740 0 0 {name=l357 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2580 -1720 0 0 {name=l358 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2580 -1700 0 0 {name=l359 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2580 -1680 0 0 {name=l360 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2580 -1660 0 0 {name=l361 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2580 -1640 0 0 {name=l362 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2580 -1620 0 0 {name=l363 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2580 -1600 0 0 {name=l364 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2580 -1580 0 0 {name=l365 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2580 -1560 0 0 {name=l366 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2580 -1540 0 0 {name=l367 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2580 -1520 0 0 {name=l368 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2580 -1500 0 0 {name=l369 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2580 -1480 0 0 {name=l370 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2580 -1460 0 0 {name=l371 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2580 -1440 0 0 {name=l372 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2580 -1420 0 0 {name=l373 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2580 -1400 0 0 {name=l374 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2580 -1380 0 0 {name=l375 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2580 -1360 0 0 {name=l376 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2580 -1340 0 0 {name=l377 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2580 -1320 0 0 {name=l378 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2580 -1300 0 0 {name=l379 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2580 -1280 0 0 {name=l380 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2580 -1260 0 0 {name=l381 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2580 -1240 0 0 {name=l382 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2580 -1220 0 0 {name=l383 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2580 -1200 0 0 {name=l384 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2580 -1180 0 0 {name=l385 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2580 -1140 0 0 {name=l386 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2580 -1160 0 0 {name=l387 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2920 -1760 2 0 {name=l388 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2920 -1740 2 0 {name=l389 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2920 -1720 2 0 {name=l390 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2920 -1700 2 0 {name=l391 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2920 -1680 2 0 {name=l392 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2920 -1660 2 0 {name=l393 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2920 -1640 2 0 {name=l394 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2920 -1620 2 0 {name=l395 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2920 -1600 2 0 {name=l396 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2920 -1580 2 0 {name=l397 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2920 -1560 2 0 {name=l398 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2920 -1540 2 0 {name=l399 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2920 -1520 2 0 {name=l400 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2920 -1500 2 0 {name=l401 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2920 -1480 2 0 {name=l402 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2920 -1460 2 0 {name=l403 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2920 -1440 2 0 {name=l404 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2920 -1420 2 0 {name=l405 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2920 -1400 2 0 {name=l406 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2920 -1380 2 0 {name=l407 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2920 -1360 2 0 {name=l408 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2920 -1340 2 0 {name=l409 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2920 -1320 2 0 {name=l410 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2920 -1300 2 0 {name=l411 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2920 -1280 2 0 {name=l412 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2920 -1260 2 0 {name=l413 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2920 -1240 2 0 {name=l414 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2920 -1220 2 0 {name=l415 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2920 -1200 2 0 {name=l416 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2920 -1180 2 0 {name=l417 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2920 -1160 2 0 {name=l418 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2920 -1140 2 0 {name=l419 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2670 -1820 0 0 {name=l420 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2710 -1820 1 0 {name=l421 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2730 -1820 1 0 {name=l422 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2750 -1820 1 0 {name=l423 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2770 -1820 1 0 {name=l424 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2800 -1820 1 0 {name=l425 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2820 -1820 1 0 {name=l426 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 3290 -1510 0 0 {name=xbyte7 NF=2}
C {lab_wire.sym} 3120 -1760 0 0 {name=l427 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 3120 -1740 0 0 {name=l428 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 3120 -1720 0 0 {name=l429 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 3120 -1700 0 0 {name=l430 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 3120 -1680 0 0 {name=l431 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 3120 -1660 0 0 {name=l432 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 3120 -1640 0 0 {name=l433 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 3120 -1620 0 0 {name=l434 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 3120 -1600 0 0 {name=l435 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 3120 -1580 0 0 {name=l436 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 3120 -1560 0 0 {name=l437 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 3120 -1540 0 0 {name=l438 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 3120 -1520 0 0 {name=l439 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 3120 -1500 0 0 {name=l440 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 3120 -1480 0 0 {name=l441 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 3120 -1460 0 0 {name=l442 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 3120 -1440 0 0 {name=l443 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 3120 -1420 0 0 {name=l444 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3120 -1400 0 0 {name=l445 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3120 -1380 0 0 {name=l446 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3120 -1360 0 0 {name=l447 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3120 -1340 0 0 {name=l448 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3120 -1320 0 0 {name=l449 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3120 -1300 0 0 {name=l450 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3120 -1280 0 0 {name=l451 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3120 -1260 0 0 {name=l452 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3120 -1240 0 0 {name=l453 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3120 -1220 0 0 {name=l454 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3120 -1200 0 0 {name=l455 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3120 -1180 0 0 {name=l456 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3120 -1140 0 0 {name=l457 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3120 -1160 0 0 {name=l458 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3460 -1760 2 0 {name=l459 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3460 -1740 2 0 {name=l460 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3460 -1720 2 0 {name=l461 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3460 -1700 2 0 {name=l462 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3460 -1680 2 0 {name=l463 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3460 -1660 2 0 {name=l464 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3460 -1640 2 0 {name=l465 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3460 -1620 2 0 {name=l466 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3460 -1600 2 0 {name=l467 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3460 -1580 2 0 {name=l468 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3460 -1560 2 0 {name=l469 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3460 -1540 2 0 {name=l470 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3460 -1520 2 0 {name=l471 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3460 -1500 2 0 {name=l472 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3460 -1480 2 0 {name=l473 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3460 -1460 2 0 {name=l474 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3460 -1440 2 0 {name=l475 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3460 -1420 2 0 {name=l476 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3460 -1400 2 0 {name=l477 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3460 -1380 2 0 {name=l478 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3460 -1360 2 0 {name=l479 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3460 -1340 2 0 {name=l480 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3460 -1320 2 0 {name=l481 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3460 -1300 2 0 {name=l482 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3460 -1280 2 0 {name=l483 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3460 -1260 2 0 {name=l484 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3460 -1240 2 0 {name=l485 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3460 -1220 2 0 {name=l486 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3460 -1200 2 0 {name=l487 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3460 -1180 2 0 {name=l488 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3460 -1160 2 0 {name=l489 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3460 -1140 2 0 {name=l490 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 3250 -1820 1 0 {name=l492 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3270 -1820 1 0 {name=l493 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 3290 -1820 1 0 {name=l494 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 3310 -1820 1 0 {name=l495 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 3340 -1820 1 0 {name=l496 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3360 -1820 1 0 {name=l497 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 3810 -1510 0 0 {name=xbyte8 NF=2}
C {lab_wire.sym} 3640 -1760 0 0 {name=l498 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 3640 -1740 0 0 {name=l499 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 3640 -1720 0 0 {name=l500 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 3640 -1700 0 0 {name=l501 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 3640 -1680 0 0 {name=l502 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 3640 -1660 0 0 {name=l503 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 3640 -1640 0 0 {name=l504 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 3640 -1620 0 0 {name=l505 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 3640 -1600 0 0 {name=l506 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 3640 -1580 0 0 {name=l507 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 3640 -1560 0 0 {name=l508 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 3640 -1540 0 0 {name=l509 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 3640 -1520 0 0 {name=l510 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 3640 -1500 0 0 {name=l511 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 3640 -1480 0 0 {name=l512 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 3640 -1460 0 0 {name=l513 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 3640 -1440 0 0 {name=l514 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 3640 -1420 0 0 {name=l515 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3640 -1400 0 0 {name=l516 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3640 -1380 0 0 {name=l517 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3640 -1360 0 0 {name=l518 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3640 -1340 0 0 {name=l519 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3640 -1320 0 0 {name=l520 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3640 -1300 0 0 {name=l521 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3640 -1280 0 0 {name=l522 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3640 -1260 0 0 {name=l523 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3640 -1240 0 0 {name=l524 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3640 -1220 0 0 {name=l525 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3640 -1200 0 0 {name=l526 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3640 -1180 0 0 {name=l527 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3640 -1140 0 0 {name=l528 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3640 -1160 0 0 {name=l529 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3980 -1760 2 0 {name=l530 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3980 -1740 2 0 {name=l531 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3980 -1720 2 0 {name=l532 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3980 -1700 2 0 {name=l533 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3980 -1680 2 0 {name=l534 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3980 -1660 2 0 {name=l535 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3980 -1640 2 0 {name=l536 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3980 -1620 2 0 {name=l537 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3980 -1600 2 0 {name=l538 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3980 -1580 2 0 {name=l539 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3980 -1560 2 0 {name=l540 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3980 -1540 2 0 {name=l541 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3980 -1520 2 0 {name=l542 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3980 -1500 2 0 {name=l543 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3980 -1480 2 0 {name=l544 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3980 -1460 2 0 {name=l545 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3980 -1440 2 0 {name=l546 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3980 -1420 2 0 {name=l547 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3980 -1400 2 0 {name=l548 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3980 -1380 2 0 {name=l549 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3980 -1360 2 0 {name=l550 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3980 -1340 2 0 {name=l551 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3980 -1320 2 0 {name=l552 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3980 -1300 2 0 {name=l553 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3980 -1280 2 0 {name=l554 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3980 -1260 2 0 {name=l555 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3980 -1240 2 0 {name=l556 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3980 -1220 2 0 {name=l557 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3980 -1200 2 0 {name=l558 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3980 -1180 2 0 {name=l559 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3980 -1160 2 0 {name=l560 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3980 -1140 2 0 {name=l561 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 3770 -1820 1 0 {name=l563 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3790 -1820 1 0 {name=l564 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 3810 -1820 1 0 {name=l565 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 3830 -1820 1 0 {name=l566 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 3860 -1820 1 0 {name=l567 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3880 -1820 1 0 {name=l568 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 130 -610 0 0 {name=xbyte9 NF=2}
C {lab_wire.sym} -40 -860 0 0 {name=l569 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} -40 -840 0 0 {name=l570 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} -40 -820 0 0 {name=l571 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} -40 -800 0 0 {name=l572 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} -40 -780 0 0 {name=l573 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} -40 -760 0 0 {name=l574 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} -40 -740 0 0 {name=l575 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} -40 -720 0 0 {name=l576 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} -40 -700 0 0 {name=l577 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} -40 -680 0 0 {name=l578 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} -40 -660 0 0 {name=l579 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} -40 -640 0 0 {name=l580 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} -40 -620 0 0 {name=l581 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} -40 -600 0 0 {name=l582 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} -40 -580 0 0 {name=l583 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} -40 -560 0 0 {name=l584 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} -40 -540 0 0 {name=l585 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} -40 -520 0 0 {name=l586 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} -40 -500 0 0 {name=l587 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} -40 -480 0 0 {name=l588 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} -40 -460 0 0 {name=l589 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} -40 -440 0 0 {name=l590 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} -40 -420 0 0 {name=l591 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} -40 -400 0 0 {name=l592 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} -40 -380 0 0 {name=l593 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} -40 -360 0 0 {name=l594 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} -40 -340 0 0 {name=l595 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} -40 -320 0 0 {name=l596 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} -40 -300 0 0 {name=l597 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} -40 -280 0 0 {name=l598 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} -40 -240 0 0 {name=l599 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} -40 -260 0 0 {name=l600 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 300 -860 2 0 {name=l601 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 300 -840 2 0 {name=l602 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 300 -820 2 0 {name=l603 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 300 -800 2 0 {name=l604 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 300 -780 2 0 {name=l605 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 300 -760 2 0 {name=l606 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 300 -740 2 0 {name=l607 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 300 -720 2 0 {name=l608 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 300 -700 2 0 {name=l609 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 300 -680 2 0 {name=l610 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 300 -660 2 0 {name=l611 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 300 -640 2 0 {name=l612 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 300 -620 2 0 {name=l613 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 300 -600 2 0 {name=l614 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 300 -580 2 0 {name=l615 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 300 -560 2 0 {name=l616 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 300 -540 2 0 {name=l617 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 300 -520 2 0 {name=l618 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 300 -500 2 0 {name=l619 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 300 -480 2 0 {name=l620 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 300 -460 2 0 {name=l621 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 300 -440 2 0 {name=l622 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 300 -420 2 0 {name=l623 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 300 -400 2 0 {name=l624 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 300 -380 2 0 {name=l625 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 300 -360 2 0 {name=l626 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 300 -340 2 0 {name=l627 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 300 -320 2 0 {name=l628 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 300 -300 2 0 {name=l629 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 300 -280 2 0 {name=l630 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 300 -260 2 0 {name=l631 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 300 -240 2 0 {name=l632 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 90 -920 1 0 {name=l634 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 110 -920 1 0 {name=l635 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 130 -920 1 0 {name=l636 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 150 -920 1 0 {name=l637 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 180 -920 1 0 {name=l638 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 200 -920 1 0 {name=l639 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 650 -610 0 0 {name=xbyte10 NF=2}
C {lab_wire.sym} 480 -860 0 0 {name=l640 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 480 -840 0 0 {name=l641 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 480 -820 0 0 {name=l642 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 480 -800 0 0 {name=l643 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 480 -780 0 0 {name=l644 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 480 -760 0 0 {name=l645 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 480 -740 0 0 {name=l646 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 480 -720 0 0 {name=l647 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 480 -700 0 0 {name=l648 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 480 -680 0 0 {name=l649 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 480 -660 0 0 {name=l650 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 480 -640 0 0 {name=l651 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 480 -620 0 0 {name=l652 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 480 -600 0 0 {name=l653 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 480 -580 0 0 {name=l654 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 480 -560 0 0 {name=l655 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 480 -540 0 0 {name=l656 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 480 -520 0 0 {name=l657 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 480 -500 0 0 {name=l658 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 480 -480 0 0 {name=l659 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 480 -460 0 0 {name=l660 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 480 -440 0 0 {name=l661 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 480 -420 0 0 {name=l662 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 480 -400 0 0 {name=l663 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 480 -380 0 0 {name=l664 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 480 -360 0 0 {name=l665 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 480 -340 0 0 {name=l666 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 480 -320 0 0 {name=l667 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 480 -300 0 0 {name=l668 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 480 -280 0 0 {name=l669 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 480 -240 0 0 {name=l670 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 480 -260 0 0 {name=l671 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 820 -860 2 0 {name=l672 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 820 -840 2 0 {name=l673 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 820 -820 2 0 {name=l674 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 820 -800 2 0 {name=l675 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 820 -780 2 0 {name=l676 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 820 -760 2 0 {name=l677 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 820 -740 2 0 {name=l678 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 820 -720 2 0 {name=l679 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 820 -700 2 0 {name=l680 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 820 -680 2 0 {name=l681 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 820 -660 2 0 {name=l682 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 820 -640 2 0 {name=l683 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 820 -620 2 0 {name=l684 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 820 -600 2 0 {name=l685 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 820 -580 2 0 {name=l686 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 820 -560 2 0 {name=l687 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 820 -540 2 0 {name=l688 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 820 -520 2 0 {name=l689 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 820 -500 2 0 {name=l690 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 820 -480 2 0 {name=l691 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 820 -460 2 0 {name=l692 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 820 -440 2 0 {name=l693 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 820 -420 2 0 {name=l694 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 820 -400 2 0 {name=l695 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 820 -380 2 0 {name=l696 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 820 -360 2 0 {name=l697 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 820 -340 2 0 {name=l698 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 820 -320 2 0 {name=l699 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 820 -300 2 0 {name=l700 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 820 -280 2 0 {name=l701 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 820 -260 2 0 {name=l702 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 820 -240 2 0 {name=l703 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 610 -920 1 0 {name=l705 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 630 -920 1 0 {name=l706 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 650 -920 1 0 {name=l707 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 670 -920 1 0 {name=l708 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 700 -920 1 0 {name=l709 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 720 -920 1 0 {name=l710 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 1190 -610 0 0 {name=xbyte11 NF=2}
C {lab_wire.sym} 1020 -860 0 0 {name=l711 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1020 -840 0 0 {name=l712 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1020 -820 0 0 {name=l713 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1020 -800 0 0 {name=l714 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1020 -780 0 0 {name=l715 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1020 -760 0 0 {name=l716 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1020 -740 0 0 {name=l717 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1020 -720 0 0 {name=l718 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1020 -700 0 0 {name=l719 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1020 -680 0 0 {name=l720 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1020 -660 0 0 {name=l721 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1020 -640 0 0 {name=l722 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1020 -620 0 0 {name=l723 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1020 -600 0 0 {name=l724 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1020 -580 0 0 {name=l725 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1020 -560 0 0 {name=l726 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1020 -540 0 0 {name=l727 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1020 -520 0 0 {name=l728 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1020 -500 0 0 {name=l729 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1020 -480 0 0 {name=l730 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1020 -460 0 0 {name=l731 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1020 -440 0 0 {name=l732 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1020 -420 0 0 {name=l733 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1020 -400 0 0 {name=l734 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1020 -380 0 0 {name=l735 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1020 -360 0 0 {name=l736 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1020 -340 0 0 {name=l737 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1020 -320 0 0 {name=l738 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1020 -300 0 0 {name=l739 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1020 -280 0 0 {name=l740 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1020 -240 0 0 {name=l741 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1020 -260 0 0 {name=l742 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1360 -860 2 0 {name=l743 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1360 -840 2 0 {name=l744 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1360 -820 2 0 {name=l745 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1360 -800 2 0 {name=l746 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1360 -780 2 0 {name=l747 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1360 -760 2 0 {name=l748 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1360 -740 2 0 {name=l749 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1360 -720 2 0 {name=l750 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1360 -700 2 0 {name=l751 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1360 -680 2 0 {name=l752 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1360 -660 2 0 {name=l753 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1360 -640 2 0 {name=l754 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1360 -620 2 0 {name=l755 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1360 -600 2 0 {name=l756 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1360 -580 2 0 {name=l757 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1360 -560 2 0 {name=l758 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1360 -540 2 0 {name=l759 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1360 -520 2 0 {name=l760 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1360 -500 2 0 {name=l761 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1360 -480 2 0 {name=l762 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1360 -460 2 0 {name=l763 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1360 -440 2 0 {name=l764 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1360 -420 2 0 {name=l765 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1360 -400 2 0 {name=l766 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1360 -380 2 0 {name=l767 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1360 -360 2 0 {name=l768 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1360 -340 2 0 {name=l769 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1360 -320 2 0 {name=l770 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1360 -300 2 0 {name=l771 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1360 -280 2 0 {name=l772 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1360 -260 2 0 {name=l773 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1360 -240 2 0 {name=l774 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1150 -920 1 0 {name=l776 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1170 -920 1 0 {name=l777 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1190 -920 1 0 {name=l778 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1210 -920 1 0 {name=l779 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1240 -920 1 0 {name=l780 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1260 -920 1 0 {name=l781 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 1710 -610 0 0 {name=xbyte12 NF=2}
C {lab_wire.sym} 1540 -860 0 0 {name=l782 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1540 -840 0 0 {name=l783 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1540 -820 0 0 {name=l784 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1540 -800 0 0 {name=l785 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1540 -780 0 0 {name=l786 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1540 -760 0 0 {name=l787 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1540 -740 0 0 {name=l788 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1540 -720 0 0 {name=l789 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1540 -700 0 0 {name=l790 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1540 -680 0 0 {name=l791 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1540 -660 0 0 {name=l792 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1540 -640 0 0 {name=l793 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1540 -620 0 0 {name=l794 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1540 -600 0 0 {name=l795 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1540 -580 0 0 {name=l796 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1540 -560 0 0 {name=l797 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1540 -540 0 0 {name=l798 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1540 -520 0 0 {name=l799 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1540 -500 0 0 {name=l800 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1540 -480 0 0 {name=l801 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1540 -460 0 0 {name=l802 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1540 -440 0 0 {name=l803 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1540 -420 0 0 {name=l804 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1540 -400 0 0 {name=l805 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1540 -380 0 0 {name=l806 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1540 -360 0 0 {name=l807 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1540 -340 0 0 {name=l808 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1540 -320 0 0 {name=l809 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1540 -300 0 0 {name=l810 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1540 -280 0 0 {name=l811 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1540 -240 0 0 {name=l812 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1540 -260 0 0 {name=l813 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1880 -860 2 0 {name=l814 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1880 -840 2 0 {name=l815 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1880 -820 2 0 {name=l816 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1880 -800 2 0 {name=l817 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1880 -780 2 0 {name=l818 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1880 -760 2 0 {name=l819 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1880 -740 2 0 {name=l820 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1880 -720 2 0 {name=l821 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1880 -700 2 0 {name=l822 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1880 -680 2 0 {name=l823 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1880 -660 2 0 {name=l824 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1880 -640 2 0 {name=l825 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1880 -620 2 0 {name=l826 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1880 -600 2 0 {name=l827 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1880 -580 2 0 {name=l828 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1880 -560 2 0 {name=l829 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1880 -540 2 0 {name=l830 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1880 -520 2 0 {name=l831 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1880 -500 2 0 {name=l832 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1880 -480 2 0 {name=l833 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1880 -460 2 0 {name=l834 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1880 -440 2 0 {name=l835 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1880 -420 2 0 {name=l836 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1880 -400 2 0 {name=l837 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1880 -380 2 0 {name=l838 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1880 -360 2 0 {name=l839 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1880 -340 2 0 {name=l840 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1880 -320 2 0 {name=l841 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1880 -300 2 0 {name=l842 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1880 -280 2 0 {name=l843 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1880 -260 2 0 {name=l844 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1880 -240 2 0 {name=l845 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1670 -920 1 0 {name=l847 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1690 -920 1 0 {name=l848 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1710 -920 1 0 {name=l849 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1730 -920 1 0 {name=l850 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1760 -920 1 0 {name=l851 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1780 -920 1 0 {name=l852 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 2230 -610 0 0 {name=xbyte13 NF=2}
C {lab_wire.sym} 2060 -860 0 0 {name=l853 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2060 -840 0 0 {name=l854 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2060 -820 0 0 {name=l855 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2060 -800 0 0 {name=l856 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2060 -780 0 0 {name=l857 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2060 -760 0 0 {name=l858 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2060 -740 0 0 {name=l859 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2060 -720 0 0 {name=l860 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2060 -700 0 0 {name=l861 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2060 -680 0 0 {name=l862 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2060 -660 0 0 {name=l863 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2060 -640 0 0 {name=l864 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2060 -620 0 0 {name=l865 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2060 -600 0 0 {name=l866 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2060 -580 0 0 {name=l867 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2060 -560 0 0 {name=l868 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2060 -540 0 0 {name=l869 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2060 -520 0 0 {name=l870 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2060 -500 0 0 {name=l871 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2060 -480 0 0 {name=l872 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2060 -460 0 0 {name=l873 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2060 -440 0 0 {name=l874 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2060 -420 0 0 {name=l875 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2060 -400 0 0 {name=l876 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2060 -380 0 0 {name=l877 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2060 -360 0 0 {name=l878 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2060 -340 0 0 {name=l879 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2060 -320 0 0 {name=l880 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2060 -300 0 0 {name=l881 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2060 -280 0 0 {name=l882 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2060 -240 0 0 {name=l883 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2060 -260 0 0 {name=l884 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2400 -860 2 0 {name=l885 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2400 -840 2 0 {name=l886 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2400 -820 2 0 {name=l887 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2400 -800 2 0 {name=l888 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2400 -780 2 0 {name=l889 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2400 -760 2 0 {name=l890 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2400 -740 2 0 {name=l891 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2400 -720 2 0 {name=l892 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2400 -700 2 0 {name=l893 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2400 -680 2 0 {name=l894 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2400 -660 2 0 {name=l895 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2400 -640 2 0 {name=l896 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2400 -620 2 0 {name=l897 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2400 -600 2 0 {name=l898 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2400 -580 2 0 {name=l899 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2400 -560 2 0 {name=l900 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2400 -540 2 0 {name=l901 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2400 -520 2 0 {name=l902 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2400 -500 2 0 {name=l903 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2400 -480 2 0 {name=l904 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2400 -460 2 0 {name=l905 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2400 -440 2 0 {name=l906 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2400 -420 2 0 {name=l907 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2400 -400 2 0 {name=l908 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2400 -380 2 0 {name=l909 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2400 -360 2 0 {name=l910 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2400 -340 2 0 {name=l911 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2400 -320 2 0 {name=l912 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2400 -300 2 0 {name=l913 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2400 -280 2 0 {name=l914 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2400 -260 2 0 {name=l915 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2400 -240 2 0 {name=l916 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2190 -920 1 0 {name=l918 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2210 -920 1 0 {name=l919 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2230 -920 1 0 {name=l920 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2250 -920 1 0 {name=l921 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2280 -920 1 0 {name=l922 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2300 -920 1 0 {name=l923 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 2750 -610 0 0 {name=xbyte14 NF=2}
C {lab_wire.sym} 2580 -860 0 0 {name=l924 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2580 -840 0 0 {name=l925 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2580 -820 0 0 {name=l926 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2580 -800 0 0 {name=l927 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2580 -780 0 0 {name=l928 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2580 -760 0 0 {name=l929 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2580 -740 0 0 {name=l930 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2580 -720 0 0 {name=l931 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2580 -700 0 0 {name=l932 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2580 -680 0 0 {name=l933 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2580 -660 0 0 {name=l934 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2580 -640 0 0 {name=l935 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2580 -620 0 0 {name=l936 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2580 -600 0 0 {name=l937 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2580 -580 0 0 {name=l938 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2580 -560 0 0 {name=l939 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2580 -540 0 0 {name=l940 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2580 -520 0 0 {name=l941 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2580 -500 0 0 {name=l942 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2580 -480 0 0 {name=l943 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2580 -460 0 0 {name=l944 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2580 -440 0 0 {name=l945 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2580 -420 0 0 {name=l946 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2580 -400 0 0 {name=l947 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2580 -380 0 0 {name=l948 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2580 -360 0 0 {name=l949 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2580 -340 0 0 {name=l950 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2580 -320 0 0 {name=l951 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2580 -300 0 0 {name=l952 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2580 -280 0 0 {name=l953 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2580 -240 0 0 {name=l954 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2580 -260 0 0 {name=l955 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2920 -860 2 0 {name=l956 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2920 -840 2 0 {name=l957 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2920 -820 2 0 {name=l958 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2920 -800 2 0 {name=l959 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2920 -780 2 0 {name=l960 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2920 -760 2 0 {name=l961 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2920 -740 2 0 {name=l962 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2920 -720 2 0 {name=l963 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2920 -700 2 0 {name=l964 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2920 -680 2 0 {name=l965 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2920 -660 2 0 {name=l966 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2920 -640 2 0 {name=l967 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2920 -620 2 0 {name=l968 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2920 -600 2 0 {name=l969 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2920 -580 2 0 {name=l970 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2920 -560 2 0 {name=l971 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2920 -540 2 0 {name=l972 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2920 -520 2 0 {name=l973 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2920 -500 2 0 {name=l974 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2920 -480 2 0 {name=l975 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2920 -460 2 0 {name=l976 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2920 -440 2 0 {name=l977 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2920 -420 2 0 {name=l978 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2920 -400 2 0 {name=l979 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2920 -380 2 0 {name=l980 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2920 -360 2 0 {name=l981 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2920 -340 2 0 {name=l982 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2920 -320 2 0 {name=l983 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2920 -300 2 0 {name=l984 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2920 -280 2 0 {name=l985 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2920 -260 2 0 {name=l986 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2920 -240 2 0 {name=l987 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2710 -920 1 0 {name=l989 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2730 -920 1 0 {name=l990 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2750 -920 1 0 {name=l991 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2770 -920 1 0 {name=l992 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2800 -920 1 0 {name=l993 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2820 -920 1 0 {name=l994 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 3290 -610 0 0 {name=xbyte15 NF=2}
C {lab_wire.sym} 3120 -860 0 0 {name=l995 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 3120 -840 0 0 {name=l996 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 3120 -820 0 0 {name=l997 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 3120 -800 0 0 {name=l998 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 3120 -780 0 0 {name=l999 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 3120 -760 0 0 {name=l1000 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 3120 -740 0 0 {name=l1001 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 3120 -720 0 0 {name=l1002 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 3120 -700 0 0 {name=l1003 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 3120 -680 0 0 {name=l1004 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 3120 -660 0 0 {name=l1005 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 3120 -640 0 0 {name=l1006 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 3120 -620 0 0 {name=l1007 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 3120 -600 0 0 {name=l1008 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 3120 -580 0 0 {name=l1009 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 3120 -560 0 0 {name=l1010 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 3120 -540 0 0 {name=l1011 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 3120 -520 0 0 {name=l1012 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3120 -500 0 0 {name=l1013 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3120 -480 0 0 {name=l1014 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3120 -460 0 0 {name=l1015 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3120 -440 0 0 {name=l1016 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3120 -420 0 0 {name=l1017 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3120 -400 0 0 {name=l1018 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3120 -380 0 0 {name=l1019 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3120 -360 0 0 {name=l1020 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3120 -340 0 0 {name=l1021 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3120 -320 0 0 {name=l1022 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3120 -300 0 0 {name=l1023 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3120 -280 0 0 {name=l1024 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3120 -240 0 0 {name=l1025 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3120 -260 0 0 {name=l1026 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3460 -860 2 0 {name=l1027 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3460 -840 2 0 {name=l1028 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3460 -820 2 0 {name=l1029 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3460 -800 2 0 {name=l1030 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3460 -780 2 0 {name=l1031 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3460 -760 2 0 {name=l1032 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3460 -740 2 0 {name=l1033 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3460 -720 2 0 {name=l1034 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3460 -700 2 0 {name=l1035 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3460 -680 2 0 {name=l1036 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3460 -660 2 0 {name=l1037 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3460 -640 2 0 {name=l1038 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3460 -620 2 0 {name=l1039 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3460 -600 2 0 {name=l1040 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3460 -580 2 0 {name=l1041 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3460 -560 2 0 {name=l1042 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3460 -540 2 0 {name=l1043 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3460 -520 2 0 {name=l1044 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3460 -500 2 0 {name=l1045 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3460 -480 2 0 {name=l1046 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3460 -460 2 0 {name=l1047 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3460 -440 2 0 {name=l1048 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3460 -420 2 0 {name=l1049 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3460 -400 2 0 {name=l1050 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3460 -380 2 0 {name=l1051 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3460 -360 2 0 {name=l1052 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3460 -340 2 0 {name=l1053 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3460 -320 2 0 {name=l1054 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3460 -300 2 0 {name=l1055 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3460 -280 2 0 {name=l1056 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3460 -260 2 0 {name=l1057 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3460 -240 2 0 {name=l1058 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 3250 -920 1 0 {name=l1060 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3270 -920 1 0 {name=l1061 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 3290 -920 1 0 {name=l1062 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 3310 -920 1 0 {name=l1063 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 3340 -920 1 0 {name=l1064 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3360 -920 1 0 {name=l1065 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 3810 -610 0 0 {name=xbyte16 NF=2}
C {lab_wire.sym} 3640 -860 0 0 {name=l1066 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 3640 -840 0 0 {name=l1067 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 3640 -820 0 0 {name=l1068 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 3640 -800 0 0 {name=l1069 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 3640 -780 0 0 {name=l1070 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 3640 -760 0 0 {name=l1071 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 3640 -740 0 0 {name=l1072 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 3640 -720 0 0 {name=l1073 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 3640 -700 0 0 {name=l1074 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 3640 -680 0 0 {name=l1075 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 3640 -660 0 0 {name=l1076 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 3640 -640 0 0 {name=l1077 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 3640 -620 0 0 {name=l1078 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 3640 -600 0 0 {name=l1079 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 3640 -580 0 0 {name=l1080 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 3640 -560 0 0 {name=l1081 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 3640 -540 0 0 {name=l1082 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 3640 -520 0 0 {name=l1083 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3640 -500 0 0 {name=l1084 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3640 -480 0 0 {name=l1085 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3640 -460 0 0 {name=l1086 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3640 -440 0 0 {name=l1087 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3640 -420 0 0 {name=l1088 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3640 -400 0 0 {name=l1089 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3640 -380 0 0 {name=l1090 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3640 -360 0 0 {name=l1091 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3640 -340 0 0 {name=l1092 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3640 -320 0 0 {name=l1093 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3640 -300 0 0 {name=l1094 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3640 -280 0 0 {name=l1095 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3640 -240 0 0 {name=l1096 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3640 -260 0 0 {name=l1097 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3980 -860 2 0 {name=l1098 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3980 -840 2 0 {name=l1099 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3980 -820 2 0 {name=l1100 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3980 -800 2 0 {name=l1101 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3980 -780 2 0 {name=l1102 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3980 -760 2 0 {name=l1103 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3980 -740 2 0 {name=l1104 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3980 -720 2 0 {name=l1105 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3980 -700 2 0 {name=l1106 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3980 -680 2 0 {name=l1107 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3980 -660 2 0 {name=l1108 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3980 -640 2 0 {name=l1109 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3980 -620 2 0 {name=l1110 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3980 -600 2 0 {name=l1111 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3980 -580 2 0 {name=l1112 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3980 -560 2 0 {name=l1113 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3980 -540 2 0 {name=l1114 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3980 -520 2 0 {name=l1115 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3980 -500 2 0 {name=l1116 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3980 -480 2 0 {name=l1117 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3980 -460 2 0 {name=l1118 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3980 -440 2 0 {name=l1119 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3980 -420 2 0 {name=l1120 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3980 -400 2 0 {name=l1121 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3980 -380 2 0 {name=l1122 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3980 -360 2 0 {name=l1123 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3980 -340 2 0 {name=l1124 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3980 -320 2 0 {name=l1125 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3980 -300 2 0 {name=l1126 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3980 -280 2 0 {name=l1127 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3980 -260 2 0 {name=l1128 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3980 -240 2 0 {name=l1129 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 3770 -920 1 0 {name=l1131 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3790 -920 1 0 {name=l1132 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 3810 -920 1 0 {name=l1133 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 3830 -920 1 0 {name=l1134 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 3860 -920 1 0 {name=l1135 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3880 -920 1 0 {name=l1136 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 140 340 0 0 {name=xbyte17 NF=2}
C {lab_wire.sym} -30 90 0 0 {name=l1137 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} -30 110 0 0 {name=l1138 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} -30 130 0 0 {name=l1139 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} -30 150 0 0 {name=l1140 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} -30 170 0 0 {name=l1141 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} -30 190 0 0 {name=l1142 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} -30 210 0 0 {name=l1143 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} -30 230 0 0 {name=l1144 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} -30 250 0 0 {name=l1145 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} -30 270 0 0 {name=l1146 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} -30 290 0 0 {name=l1147 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} -30 310 0 0 {name=l1148 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} -30 330 0 0 {name=l1149 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} -30 350 0 0 {name=l1150 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} -30 370 0 0 {name=l1151 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} -30 390 0 0 {name=l1152 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} -30 410 0 0 {name=l1153 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} -30 430 0 0 {name=l1154 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} -30 450 0 0 {name=l1155 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} -30 470 0 0 {name=l1156 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} -30 490 0 0 {name=l1157 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} -30 510 0 0 {name=l1158 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} -30 530 0 0 {name=l1159 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} -30 550 0 0 {name=l1160 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} -30 570 0 0 {name=l1161 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} -30 590 0 0 {name=l1162 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} -30 610 0 0 {name=l1163 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} -30 630 0 0 {name=l1164 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} -30 650 0 0 {name=l1165 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} -30 670 0 0 {name=l1166 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} -30 710 0 0 {name=l1167 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} -30 690 0 0 {name=l1168 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 310 90 2 0 {name=l1169 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 310 110 2 0 {name=l1170 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 310 130 2 0 {name=l1171 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 310 150 2 0 {name=l1172 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 310 170 2 0 {name=l1173 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 310 190 2 0 {name=l1174 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 310 210 2 0 {name=l1175 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 310 230 2 0 {name=l1176 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 310 250 2 0 {name=l1177 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 310 270 2 0 {name=l1178 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 310 290 2 0 {name=l1179 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 310 310 2 0 {name=l1180 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 310 330 2 0 {name=l1181 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 310 350 2 0 {name=l1182 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 310 370 2 0 {name=l1183 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 310 390 2 0 {name=l1184 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 310 410 2 0 {name=l1185 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 310 430 2 0 {name=l1186 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 310 450 2 0 {name=l1187 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 310 470 2 0 {name=l1188 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 310 490 2 0 {name=l1189 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 310 510 2 0 {name=l1190 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 310 530 2 0 {name=l1191 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 310 550 2 0 {name=l1192 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 310 570 2 0 {name=l1193 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 310 590 2 0 {name=l1194 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 310 610 2 0 {name=l1195 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 310 630 2 0 {name=l1196 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 310 650 2 0 {name=l1197 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 310 670 2 0 {name=l1198 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 310 690 2 0 {name=l1199 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 310 710 2 0 {name=l1200 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 100 30 1 0 {name=l1202 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 120 30 1 0 {name=l1203 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 140 30 1 0 {name=l1204 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 160 30 1 0 {name=l1205 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 190 30 1 0 {name=l1206 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 210 30 1 0 {name=l1207 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 660 340 0 0 {name=xbyte18 NF=2}
C {lab_wire.sym} 490 90 0 0 {name=l1208 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 490 110 0 0 {name=l1209 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 490 130 0 0 {name=l1210 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 490 150 0 0 {name=l1211 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 490 170 0 0 {name=l1212 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 490 190 0 0 {name=l1213 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 490 210 0 0 {name=l1214 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 490 230 0 0 {name=l1215 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 490 250 0 0 {name=l1216 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 490 270 0 0 {name=l1217 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 490 290 0 0 {name=l1218 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 490 310 0 0 {name=l1219 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 490 330 0 0 {name=l1220 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 490 350 0 0 {name=l1221 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 490 370 0 0 {name=l1222 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 490 390 0 0 {name=l1223 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 490 410 0 0 {name=l1224 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 490 430 0 0 {name=l1225 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 490 450 0 0 {name=l1226 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 490 470 0 0 {name=l1227 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 490 490 0 0 {name=l1228 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 490 510 0 0 {name=l1229 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 490 530 0 0 {name=l1230 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 490 550 0 0 {name=l1231 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 490 570 0 0 {name=l1232 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 490 590 0 0 {name=l1233 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 490 610 0 0 {name=l1234 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 490 630 0 0 {name=l1235 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 490 650 0 0 {name=l1236 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 490 670 0 0 {name=l1237 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 490 710 0 0 {name=l1238 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 490 690 0 0 {name=l1239 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 830 90 2 0 {name=l1240 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 830 110 2 0 {name=l1241 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 830 130 2 0 {name=l1242 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 830 150 2 0 {name=l1243 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 830 170 2 0 {name=l1244 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 830 190 2 0 {name=l1245 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 830 210 2 0 {name=l1246 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 830 230 2 0 {name=l1247 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 830 250 2 0 {name=l1248 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 830 270 2 0 {name=l1249 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 830 290 2 0 {name=l1250 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 830 310 2 0 {name=l1251 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 830 330 2 0 {name=l1252 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 830 350 2 0 {name=l1253 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 830 370 2 0 {name=l1254 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 830 390 2 0 {name=l1255 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 830 410 2 0 {name=l1256 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 830 430 2 0 {name=l1257 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 830 450 2 0 {name=l1258 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 830 470 2 0 {name=l1259 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 830 490 2 0 {name=l1260 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 830 510 2 0 {name=l1261 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 830 530 2 0 {name=l1262 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 830 550 2 0 {name=l1263 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 830 570 2 0 {name=l1264 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 830 590 2 0 {name=l1265 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 830 610 2 0 {name=l1266 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 830 630 2 0 {name=l1267 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 830 650 2 0 {name=l1268 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 830 670 2 0 {name=l1269 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 830 690 2 0 {name=l1270 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 830 710 2 0 {name=l1271 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 620 30 1 0 {name=l1273 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 640 30 1 0 {name=l1274 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 660 30 1 0 {name=l1275 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 680 30 1 0 {name=l1276 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 710 30 1 0 {name=l1277 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 730 30 1 0 {name=l1278 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 1200 340 0 0 {name=xbyte19 NF=2}
C {lab_wire.sym} 1030 90 0 0 {name=l1279 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1030 110 0 0 {name=l1280 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1030 130 0 0 {name=l1281 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1030 150 0 0 {name=l1282 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1030 170 0 0 {name=l1283 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1030 190 0 0 {name=l1284 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1030 210 0 0 {name=l1285 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1030 230 0 0 {name=l1286 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1030 250 0 0 {name=l1287 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1030 270 0 0 {name=l1288 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1030 290 0 0 {name=l1289 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1030 310 0 0 {name=l1290 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1030 330 0 0 {name=l1291 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1030 350 0 0 {name=l1292 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1030 370 0 0 {name=l1293 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1030 390 0 0 {name=l1294 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1030 410 0 0 {name=l1295 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1030 430 0 0 {name=l1296 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1030 450 0 0 {name=l1297 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1030 470 0 0 {name=l1298 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1030 490 0 0 {name=l1299 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1030 510 0 0 {name=l1300 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1030 530 0 0 {name=l1301 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1030 550 0 0 {name=l1302 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1030 570 0 0 {name=l1303 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1030 590 0 0 {name=l1304 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1030 610 0 0 {name=l1305 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1030 630 0 0 {name=l1306 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1030 650 0 0 {name=l1307 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1030 670 0 0 {name=l1308 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1030 710 0 0 {name=l1309 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1030 690 0 0 {name=l1310 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1370 90 2 0 {name=l1311 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1370 110 2 0 {name=l1312 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1370 130 2 0 {name=l1313 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1370 150 2 0 {name=l1314 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1370 170 2 0 {name=l1315 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1370 190 2 0 {name=l1316 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1370 210 2 0 {name=l1317 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1370 230 2 0 {name=l1318 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1370 250 2 0 {name=l1319 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1370 270 2 0 {name=l1320 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1370 290 2 0 {name=l1321 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1370 310 2 0 {name=l1322 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1370 330 2 0 {name=l1323 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1370 350 2 0 {name=l1324 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1370 370 2 0 {name=l1325 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1370 390 2 0 {name=l1326 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1370 410 2 0 {name=l1327 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1370 430 2 0 {name=l1328 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1370 450 2 0 {name=l1329 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1370 470 2 0 {name=l1330 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1370 490 2 0 {name=l1331 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1370 510 2 0 {name=l1332 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1370 530 2 0 {name=l1333 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1370 550 2 0 {name=l1334 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1370 570 2 0 {name=l1335 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1370 590 2 0 {name=l1336 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1370 610 2 0 {name=l1337 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1370 630 2 0 {name=l1338 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1370 650 2 0 {name=l1339 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1370 670 2 0 {name=l1340 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1370 690 2 0 {name=l1341 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1370 710 2 0 {name=l1342 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1160 30 1 0 {name=l1344 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1180 30 1 0 {name=l1345 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1200 30 1 0 {name=l1346 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1220 30 1 0 {name=l1347 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1250 30 1 0 {name=l1348 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1270 30 1 0 {name=l1349 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 1720 340 0 0 {name=xbyte20 NF=2}
C {lab_wire.sym} 1550 90 0 0 {name=l1350 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1550 110 0 0 {name=l1351 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1550 130 0 0 {name=l1352 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1550 150 0 0 {name=l1353 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1550 170 0 0 {name=l1354 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1550 190 0 0 {name=l1355 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1550 210 0 0 {name=l1356 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1550 230 0 0 {name=l1357 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1550 250 0 0 {name=l1358 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1550 270 0 0 {name=l1359 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1550 290 0 0 {name=l1360 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1550 310 0 0 {name=l1361 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1550 330 0 0 {name=l1362 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1550 350 0 0 {name=l1363 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1550 370 0 0 {name=l1364 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1550 390 0 0 {name=l1365 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1550 410 0 0 {name=l1366 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1550 430 0 0 {name=l1367 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1550 450 0 0 {name=l1368 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1550 470 0 0 {name=l1369 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1550 490 0 0 {name=l1370 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1550 510 0 0 {name=l1371 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1550 530 0 0 {name=l1372 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1550 550 0 0 {name=l1373 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1550 570 0 0 {name=l1374 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1550 590 0 0 {name=l1375 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1550 610 0 0 {name=l1376 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1550 630 0 0 {name=l1377 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1550 650 0 0 {name=l1378 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1550 670 0 0 {name=l1379 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1550 710 0 0 {name=l1380 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1550 690 0 0 {name=l1381 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1890 90 2 0 {name=l1382 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1890 110 2 0 {name=l1383 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1890 130 2 0 {name=l1384 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1890 150 2 0 {name=l1385 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1890 170 2 0 {name=l1386 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1890 190 2 0 {name=l1387 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1890 210 2 0 {name=l1388 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1890 230 2 0 {name=l1389 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1890 250 2 0 {name=l1390 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1890 270 2 0 {name=l1391 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1890 290 2 0 {name=l1392 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1890 310 2 0 {name=l1393 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1890 330 2 0 {name=l1394 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1890 350 2 0 {name=l1395 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1890 370 2 0 {name=l1396 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1890 390 2 0 {name=l1397 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1890 410 2 0 {name=l1398 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1890 430 2 0 {name=l1399 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1890 450 2 0 {name=l1400 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1890 470 2 0 {name=l1401 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1890 490 2 0 {name=l1402 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1890 510 2 0 {name=l1403 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1890 530 2 0 {name=l1404 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1890 550 2 0 {name=l1405 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1890 570 2 0 {name=l1406 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1890 590 2 0 {name=l1407 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1890 610 2 0 {name=l1408 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1890 630 2 0 {name=l1409 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1890 650 2 0 {name=l1410 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1890 670 2 0 {name=l1411 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1890 690 2 0 {name=l1412 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1890 710 2 0 {name=l1413 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1680 30 1 0 {name=l1415 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1700 30 1 0 {name=l1416 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1720 30 1 0 {name=l1417 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1740 30 1 0 {name=l1418 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1770 30 1 0 {name=l1419 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1790 30 1 0 {name=l1420 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 2240 340 0 0 {name=xbyte21 NF=2}
C {lab_wire.sym} 2070 90 0 0 {name=l1421 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2070 110 0 0 {name=l1422 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2070 130 0 0 {name=l1423 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2070 150 0 0 {name=l1424 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2070 170 0 0 {name=l1425 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2070 190 0 0 {name=l1426 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2070 210 0 0 {name=l1427 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2070 230 0 0 {name=l1428 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2070 250 0 0 {name=l1429 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2070 270 0 0 {name=l1430 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2070 290 0 0 {name=l1431 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2070 310 0 0 {name=l1432 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2070 330 0 0 {name=l1433 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2070 350 0 0 {name=l1434 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2070 370 0 0 {name=l1435 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2070 390 0 0 {name=l1436 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2070 410 0 0 {name=l1437 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2070 430 0 0 {name=l1438 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2070 450 0 0 {name=l1439 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2070 470 0 0 {name=l1440 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2070 490 0 0 {name=l1441 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2070 510 0 0 {name=l1442 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2070 530 0 0 {name=l1443 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2070 550 0 0 {name=l1444 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2070 570 0 0 {name=l1445 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2070 590 0 0 {name=l1446 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2070 610 0 0 {name=l1447 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2070 630 0 0 {name=l1448 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2070 650 0 0 {name=l1449 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2070 670 0 0 {name=l1450 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2070 710 0 0 {name=l1451 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2070 690 0 0 {name=l1452 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2410 90 2 0 {name=l1453 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2410 110 2 0 {name=l1454 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2410 130 2 0 {name=l1455 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2410 150 2 0 {name=l1456 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2410 170 2 0 {name=l1457 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2410 190 2 0 {name=l1458 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2410 210 2 0 {name=l1459 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2410 230 2 0 {name=l1460 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2410 250 2 0 {name=l1461 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2410 270 2 0 {name=l1462 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2410 290 2 0 {name=l1463 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2410 310 2 0 {name=l1464 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2410 330 2 0 {name=l1465 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2410 350 2 0 {name=l1466 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2410 370 2 0 {name=l1467 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2410 390 2 0 {name=l1468 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2410 410 2 0 {name=l1469 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2410 430 2 0 {name=l1470 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2410 450 2 0 {name=l1471 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2410 470 2 0 {name=l1472 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2410 490 2 0 {name=l1473 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2410 510 2 0 {name=l1474 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2410 530 2 0 {name=l1475 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2410 550 2 0 {name=l1476 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2410 570 2 0 {name=l1477 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2410 590 2 0 {name=l1478 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2410 610 2 0 {name=l1479 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2410 630 2 0 {name=l1480 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2410 650 2 0 {name=l1481 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2410 670 2 0 {name=l1482 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2410 690 2 0 {name=l1483 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2410 710 2 0 {name=l1484 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2200 30 1 0 {name=l1486 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2220 30 1 0 {name=l1487 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2240 30 1 0 {name=l1488 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2260 30 1 0 {name=l1489 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2290 30 1 0 {name=l1490 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2310 30 1 0 {name=l1491 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 2760 340 0 0 {name=xbyte22 NF=2}
C {lab_wire.sym} 2590 90 0 0 {name=l1492 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2590 110 0 0 {name=l1493 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2590 130 0 0 {name=l1494 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2590 150 0 0 {name=l1495 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2590 170 0 0 {name=l1496 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2590 190 0 0 {name=l1497 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2590 210 0 0 {name=l1498 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2590 230 0 0 {name=l1499 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2590 250 0 0 {name=l1500 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2590 270 0 0 {name=l1501 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2590 290 0 0 {name=l1502 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2590 310 0 0 {name=l1503 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2590 330 0 0 {name=l1504 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2590 350 0 0 {name=l1505 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2590 370 0 0 {name=l1506 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2590 390 0 0 {name=l1507 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2590 410 0 0 {name=l1508 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2590 430 0 0 {name=l1509 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2590 450 0 0 {name=l1510 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2590 470 0 0 {name=l1511 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2590 490 0 0 {name=l1512 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2590 510 0 0 {name=l1513 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2590 530 0 0 {name=l1514 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2590 550 0 0 {name=l1515 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2590 570 0 0 {name=l1516 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2590 590 0 0 {name=l1517 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2590 610 0 0 {name=l1518 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2590 630 0 0 {name=l1519 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2590 650 0 0 {name=l1520 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2590 670 0 0 {name=l1521 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2590 710 0 0 {name=l1522 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2590 690 0 0 {name=l1523 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2930 90 2 0 {name=l1524 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2930 110 2 0 {name=l1525 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2930 130 2 0 {name=l1526 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2930 150 2 0 {name=l1527 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2930 170 2 0 {name=l1528 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2930 190 2 0 {name=l1529 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2930 210 2 0 {name=l1530 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2930 230 2 0 {name=l1531 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2930 250 2 0 {name=l1532 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2930 270 2 0 {name=l1533 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2930 290 2 0 {name=l1534 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2930 310 2 0 {name=l1535 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2930 330 2 0 {name=l1536 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2930 350 2 0 {name=l1537 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2930 370 2 0 {name=l1538 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2930 390 2 0 {name=l1539 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2930 410 2 0 {name=l1540 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2930 430 2 0 {name=l1541 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2930 450 2 0 {name=l1542 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2930 470 2 0 {name=l1543 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2930 490 2 0 {name=l1544 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2930 510 2 0 {name=l1545 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2930 530 2 0 {name=l1546 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2930 550 2 0 {name=l1547 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2930 570 2 0 {name=l1548 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2930 590 2 0 {name=l1549 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2930 610 2 0 {name=l1550 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2930 630 2 0 {name=l1551 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2930 650 2 0 {name=l1552 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2930 670 2 0 {name=l1553 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2930 690 2 0 {name=l1554 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2930 710 2 0 {name=l1555 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2720 30 1 0 {name=l1557 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2740 30 1 0 {name=l1558 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2760 30 1 0 {name=l1559 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2780 30 1 0 {name=l1560 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2810 30 1 0 {name=l1561 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2830 30 1 0 {name=l1562 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 3300 340 0 0 {name=xbyte23 NF=2}
C {lab_wire.sym} 3130 90 0 0 {name=l1563 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 3130 110 0 0 {name=l1564 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 3130 130 0 0 {name=l1565 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 3130 150 0 0 {name=l1566 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 3130 170 0 0 {name=l1567 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 3130 190 0 0 {name=l1568 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 3130 210 0 0 {name=l1569 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 3130 230 0 0 {name=l1570 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 3130 250 0 0 {name=l1571 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 3130 270 0 0 {name=l1572 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 3130 290 0 0 {name=l1573 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 3130 310 0 0 {name=l1574 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 3130 330 0 0 {name=l1575 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 3130 350 0 0 {name=l1576 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 3130 370 0 0 {name=l1577 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 3130 390 0 0 {name=l1578 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 3130 410 0 0 {name=l1579 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 3130 430 0 0 {name=l1580 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3130 450 0 0 {name=l1581 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3130 470 0 0 {name=l1582 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3130 490 0 0 {name=l1583 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3130 510 0 0 {name=l1584 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3130 530 0 0 {name=l1585 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3130 550 0 0 {name=l1586 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3130 570 0 0 {name=l1587 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3130 590 0 0 {name=l1588 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3130 610 0 0 {name=l1589 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3130 630 0 0 {name=l1590 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3130 650 0 0 {name=l1591 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3130 670 0 0 {name=l1592 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3130 710 0 0 {name=l1593 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3130 690 0 0 {name=l1594 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3470 90 2 0 {name=l1595 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3470 110 2 0 {name=l1596 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3470 130 2 0 {name=l1597 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3470 150 2 0 {name=l1598 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3470 170 2 0 {name=l1599 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3470 190 2 0 {name=l1600 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3470 210 2 0 {name=l1601 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3470 230 2 0 {name=l1602 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3470 250 2 0 {name=l1603 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3470 270 2 0 {name=l1604 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3470 290 2 0 {name=l1605 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3470 310 2 0 {name=l1606 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3470 330 2 0 {name=l1607 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3470 350 2 0 {name=l1608 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3470 370 2 0 {name=l1609 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3470 390 2 0 {name=l1610 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3470 410 2 0 {name=l1611 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3470 430 2 0 {name=l1612 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3470 450 2 0 {name=l1613 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3470 470 2 0 {name=l1614 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3470 490 2 0 {name=l1615 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3470 510 2 0 {name=l1616 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3470 530 2 0 {name=l1617 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3470 550 2 0 {name=l1618 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3470 570 2 0 {name=l1619 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3470 590 2 0 {name=l1620 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3470 610 2 0 {name=l1621 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3470 630 2 0 {name=l1622 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3470 650 2 0 {name=l1623 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3470 670 2 0 {name=l1624 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3470 690 2 0 {name=l1625 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3470 710 2 0 {name=l1626 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 3260 30 1 0 {name=l1628 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3280 30 1 0 {name=l1629 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 3300 30 1 0 {name=l1630 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 3320 30 1 0 {name=l1631 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 3350 30 1 0 {name=l1632 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3370 30 1 0 {name=l1633 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 3820 340 0 0 {name=xbyte24 NF=2}
C {lab_wire.sym} 3650 90 0 0 {name=l1634 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 3650 110 0 0 {name=l1635 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 3650 130 0 0 {name=l1636 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 3650 150 0 0 {name=l1637 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 3650 170 0 0 {name=l1638 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 3650 190 0 0 {name=l1639 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 3650 210 0 0 {name=l1640 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 3650 230 0 0 {name=l1641 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 3650 250 0 0 {name=l1642 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 3650 270 0 0 {name=l1643 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 3650 290 0 0 {name=l1644 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 3650 310 0 0 {name=l1645 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 3650 330 0 0 {name=l1646 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 3650 350 0 0 {name=l1647 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 3650 370 0 0 {name=l1648 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 3650 390 0 0 {name=l1649 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 3650 410 0 0 {name=l1650 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 3650 430 0 0 {name=l1651 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3650 450 0 0 {name=l1652 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3650 470 0 0 {name=l1653 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3650 490 0 0 {name=l1654 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3650 510 0 0 {name=l1655 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3650 530 0 0 {name=l1656 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3650 550 0 0 {name=l1657 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3650 570 0 0 {name=l1658 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3650 590 0 0 {name=l1659 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3650 610 0 0 {name=l1660 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3650 630 0 0 {name=l1661 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3650 650 0 0 {name=l1662 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3650 670 0 0 {name=l1663 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3650 710 0 0 {name=l1664 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3650 690 0 0 {name=l1665 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3990 90 2 0 {name=l1666 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3990 110 2 0 {name=l1667 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3990 130 2 0 {name=l1668 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3990 150 2 0 {name=l1669 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3990 170 2 0 {name=l1670 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3990 190 2 0 {name=l1671 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3990 210 2 0 {name=l1672 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3990 230 2 0 {name=l1673 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3990 250 2 0 {name=l1674 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3990 270 2 0 {name=l1675 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3990 290 2 0 {name=l1676 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3990 310 2 0 {name=l1677 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3990 330 2 0 {name=l1678 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3990 350 2 0 {name=l1679 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3990 370 2 0 {name=l1680 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3990 390 2 0 {name=l1681 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3990 410 2 0 {name=l1682 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3990 430 2 0 {name=l1683 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3990 450 2 0 {name=l1684 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3990 470 2 0 {name=l1685 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3990 490 2 0 {name=l1686 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3990 510 2 0 {name=l1687 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3990 530 2 0 {name=l1688 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3990 550 2 0 {name=l1689 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3990 570 2 0 {name=l1690 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3990 590 2 0 {name=l1691 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3990 610 2 0 {name=l1692 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3990 630 2 0 {name=l1693 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3990 650 2 0 {name=l1694 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3990 670 2 0 {name=l1695 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3990 690 2 0 {name=l1696 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3990 710 2 0 {name=l1697 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 3780 30 1 0 {name=l1699 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3800 30 1 0 {name=l1700 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 3820 30 1 0 {name=l1701 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 3840 30 1 0 {name=l1702 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 3870 30 1 0 {name=l1703 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3890 30 1 0 {name=l1704 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 140 1240 0 0 {name=xbyte25 NF=2}
C {lab_wire.sym} -30 990 0 0 {name=l1705 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} -30 1010 0 0 {name=l1706 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} -30 1030 0 0 {name=l1707 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} -30 1050 0 0 {name=l1708 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} -30 1070 0 0 {name=l1709 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} -30 1090 0 0 {name=l1710 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} -30 1110 0 0 {name=l1711 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} -30 1130 0 0 {name=l1712 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} -30 1150 0 0 {name=l1713 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} -30 1170 0 0 {name=l1714 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} -30 1190 0 0 {name=l1715 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} -30 1210 0 0 {name=l1716 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} -30 1230 0 0 {name=l1717 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} -30 1250 0 0 {name=l1718 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} -30 1270 0 0 {name=l1719 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} -30 1290 0 0 {name=l1720 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} -30 1310 0 0 {name=l1721 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} -30 1330 0 0 {name=l1722 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} -30 1350 0 0 {name=l1723 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} -30 1370 0 0 {name=l1724 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} -30 1390 0 0 {name=l1725 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} -30 1410 0 0 {name=l1726 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} -30 1430 0 0 {name=l1727 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} -30 1450 0 0 {name=l1728 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} -30 1470 0 0 {name=l1729 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} -30 1490 0 0 {name=l1730 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} -30 1510 0 0 {name=l1731 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} -30 1530 0 0 {name=l1732 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} -30 1550 0 0 {name=l1733 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} -30 1570 0 0 {name=l1734 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} -30 1610 0 0 {name=l1735 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} -30 1590 0 0 {name=l1736 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 310 990 2 0 {name=l1737 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 310 1010 2 0 {name=l1738 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 310 1030 2 0 {name=l1739 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 310 1050 2 0 {name=l1740 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 310 1070 2 0 {name=l1741 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 310 1090 2 0 {name=l1742 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 310 1110 2 0 {name=l1743 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 310 1130 2 0 {name=l1744 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 310 1150 2 0 {name=l1745 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 310 1170 2 0 {name=l1746 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 310 1190 2 0 {name=l1747 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 310 1210 2 0 {name=l1748 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 310 1230 2 0 {name=l1749 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 310 1250 2 0 {name=l1750 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 310 1270 2 0 {name=l1751 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 310 1290 2 0 {name=l1752 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 310 1310 2 0 {name=l1753 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 310 1330 2 0 {name=l1754 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 310 1350 2 0 {name=l1755 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 310 1370 2 0 {name=l1756 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 310 1390 2 0 {name=l1757 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 310 1410 2 0 {name=l1758 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 310 1430 2 0 {name=l1759 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 310 1450 2 0 {name=l1760 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 310 1470 2 0 {name=l1761 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 310 1490 2 0 {name=l1762 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 310 1510 2 0 {name=l1763 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 310 1530 2 0 {name=l1764 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 310 1550 2 0 {name=l1765 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 310 1570 2 0 {name=l1766 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 310 1590 2 0 {name=l1767 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 310 1610 2 0 {name=l1768 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 100 930 1 0 {name=l1770 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 120 930 1 0 {name=l1771 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 140 930 1 0 {name=l1772 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 160 930 1 0 {name=l1773 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 190 930 1 0 {name=l1774 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 210 930 1 0 {name=l1775 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 660 1240 0 0 {name=xbyte26 NF=2}
C {lab_wire.sym} 490 990 0 0 {name=l1776 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 490 1010 0 0 {name=l1777 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 490 1030 0 0 {name=l1778 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 490 1050 0 0 {name=l1779 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 490 1070 0 0 {name=l1780 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 490 1090 0 0 {name=l1781 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 490 1110 0 0 {name=l1782 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 490 1130 0 0 {name=l1783 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 490 1150 0 0 {name=l1784 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 490 1170 0 0 {name=l1785 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 490 1190 0 0 {name=l1786 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 490 1210 0 0 {name=l1787 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 490 1230 0 0 {name=l1788 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 490 1250 0 0 {name=l1789 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 490 1270 0 0 {name=l1790 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 490 1290 0 0 {name=l1791 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 490 1310 0 0 {name=l1792 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 490 1330 0 0 {name=l1793 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 490 1350 0 0 {name=l1794 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 490 1370 0 0 {name=l1795 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 490 1390 0 0 {name=l1796 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 490 1410 0 0 {name=l1797 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 490 1430 0 0 {name=l1798 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 490 1450 0 0 {name=l1799 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 490 1470 0 0 {name=l1800 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 490 1490 0 0 {name=l1801 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 490 1510 0 0 {name=l1802 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 490 1530 0 0 {name=l1803 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 490 1550 0 0 {name=l1804 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 490 1570 0 0 {name=l1805 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 490 1610 0 0 {name=l1806 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 490 1590 0 0 {name=l1807 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 830 990 2 0 {name=l1808 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 830 1010 2 0 {name=l1809 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 830 1030 2 0 {name=l1810 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 830 1050 2 0 {name=l1811 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 830 1070 2 0 {name=l1812 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 830 1090 2 0 {name=l1813 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 830 1110 2 0 {name=l1814 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 830 1130 2 0 {name=l1815 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 830 1150 2 0 {name=l1816 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 830 1170 2 0 {name=l1817 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 830 1190 2 0 {name=l1818 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 830 1210 2 0 {name=l1819 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 830 1230 2 0 {name=l1820 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 830 1250 2 0 {name=l1821 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 830 1270 2 0 {name=l1822 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 830 1290 2 0 {name=l1823 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 830 1310 2 0 {name=l1824 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 830 1330 2 0 {name=l1825 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 830 1350 2 0 {name=l1826 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 830 1370 2 0 {name=l1827 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 830 1390 2 0 {name=l1828 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 830 1410 2 0 {name=l1829 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 830 1430 2 0 {name=l1830 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 830 1450 2 0 {name=l1831 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 830 1470 2 0 {name=l1832 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 830 1490 2 0 {name=l1833 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 830 1510 2 0 {name=l1834 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 830 1530 2 0 {name=l1835 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 830 1550 2 0 {name=l1836 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 830 1570 2 0 {name=l1837 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 830 1590 2 0 {name=l1838 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 830 1610 2 0 {name=l1839 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 620 930 1 0 {name=l1841 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 640 930 1 0 {name=l1842 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 660 930 1 0 {name=l1843 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 680 930 1 0 {name=l1844 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 710 930 1 0 {name=l1845 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 730 930 1 0 {name=l1846 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 1200 1240 0 0 {name=xbyte27 NF=2}
C {lab_wire.sym} 1030 990 0 0 {name=l1847 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1030 1010 0 0 {name=l1848 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1030 1030 0 0 {name=l1849 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1030 1050 0 0 {name=l1850 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1030 1070 0 0 {name=l1851 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1030 1090 0 0 {name=l1852 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1030 1110 0 0 {name=l1853 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1030 1130 0 0 {name=l1854 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1030 1150 0 0 {name=l1855 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1030 1170 0 0 {name=l1856 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1030 1190 0 0 {name=l1857 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1030 1210 0 0 {name=l1858 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1030 1230 0 0 {name=l1859 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1030 1250 0 0 {name=l1860 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1030 1270 0 0 {name=l1861 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1030 1290 0 0 {name=l1862 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1030 1310 0 0 {name=l1863 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1030 1330 0 0 {name=l1864 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1030 1350 0 0 {name=l1865 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1030 1370 0 0 {name=l1866 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1030 1390 0 0 {name=l1867 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1030 1410 0 0 {name=l1868 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1030 1430 0 0 {name=l1869 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1030 1450 0 0 {name=l1870 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1030 1470 0 0 {name=l1871 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1030 1490 0 0 {name=l1872 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1030 1510 0 0 {name=l1873 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1030 1530 0 0 {name=l1874 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1030 1550 0 0 {name=l1875 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1030 1570 0 0 {name=l1876 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1030 1610 0 0 {name=l1877 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1030 1590 0 0 {name=l1878 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1370 990 2 0 {name=l1879 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1370 1010 2 0 {name=l1880 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1370 1030 2 0 {name=l1881 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1370 1050 2 0 {name=l1882 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1370 1070 2 0 {name=l1883 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1370 1090 2 0 {name=l1884 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1370 1110 2 0 {name=l1885 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1370 1130 2 0 {name=l1886 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1370 1150 2 0 {name=l1887 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1370 1170 2 0 {name=l1888 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1370 1190 2 0 {name=l1889 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1370 1210 2 0 {name=l1890 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1370 1230 2 0 {name=l1891 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1370 1250 2 0 {name=l1892 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1370 1270 2 0 {name=l1893 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1370 1290 2 0 {name=l1894 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1370 1310 2 0 {name=l1895 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1370 1330 2 0 {name=l1896 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1370 1350 2 0 {name=l1897 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1370 1370 2 0 {name=l1898 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1370 1390 2 0 {name=l1899 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1370 1410 2 0 {name=l1900 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1370 1430 2 0 {name=l1901 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1370 1450 2 0 {name=l1902 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1370 1470 2 0 {name=l1903 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1370 1490 2 0 {name=l1904 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1370 1510 2 0 {name=l1905 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1370 1530 2 0 {name=l1906 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1370 1550 2 0 {name=l1907 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1370 1570 2 0 {name=l1908 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1370 1590 2 0 {name=l1909 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1370 1610 2 0 {name=l1910 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1160 930 1 0 {name=l1912 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1180 930 1 0 {name=l1913 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1200 930 1 0 {name=l1914 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1220 930 1 0 {name=l1915 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1250 930 1 0 {name=l1916 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1270 930 1 0 {name=l1917 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 1720 1240 0 0 {name=xbyte28 NF=2}
C {lab_wire.sym} 1550 990 0 0 {name=l1918 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 1550 1010 0 0 {name=l1919 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 1550 1030 0 0 {name=l1920 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 1550 1050 0 0 {name=l1921 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 1550 1070 0 0 {name=l1922 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 1550 1090 0 0 {name=l1923 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 1550 1110 0 0 {name=l1924 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 1550 1130 0 0 {name=l1925 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 1550 1150 0 0 {name=l1926 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 1550 1170 0 0 {name=l1927 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 1550 1190 0 0 {name=l1928 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 1550 1210 0 0 {name=l1929 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 1550 1230 0 0 {name=l1930 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 1550 1250 0 0 {name=l1931 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 1550 1270 0 0 {name=l1932 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 1550 1290 0 0 {name=l1933 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 1550 1310 0 0 {name=l1934 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 1550 1330 0 0 {name=l1935 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1550 1350 0 0 {name=l1936 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1550 1370 0 0 {name=l1937 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1550 1390 0 0 {name=l1938 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1550 1410 0 0 {name=l1939 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1550 1430 0 0 {name=l1940 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1550 1450 0 0 {name=l1941 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1550 1470 0 0 {name=l1942 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1550 1490 0 0 {name=l1943 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1550 1510 0 0 {name=l1944 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1550 1530 0 0 {name=l1945 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1550 1550 0 0 {name=l1946 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1550 1570 0 0 {name=l1947 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1550 1610 0 0 {name=l1948 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1550 1590 0 0 {name=l1949 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1890 990 2 0 {name=l1950 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 1890 1010 2 0 {name=l1951 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 1890 1030 2 0 {name=l1952 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 1890 1050 2 0 {name=l1953 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 1890 1070 2 0 {name=l1954 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 1890 1090 2 0 {name=l1955 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 1890 1110 2 0 {name=l1956 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 1890 1130 2 0 {name=l1957 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 1890 1150 2 0 {name=l1958 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 1890 1170 2 0 {name=l1959 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 1890 1190 2 0 {name=l1960 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 1890 1210 2 0 {name=l1961 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 1890 1230 2 0 {name=l1962 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 1890 1250 2 0 {name=l1963 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 1890 1270 2 0 {name=l1964 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 1890 1290 2 0 {name=l1965 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 1890 1310 2 0 {name=l1966 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 1890 1330 2 0 {name=l1967 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 1890 1350 2 0 {name=l1968 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 1890 1370 2 0 {name=l1969 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 1890 1390 2 0 {name=l1970 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 1890 1410 2 0 {name=l1971 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 1890 1430 2 0 {name=l1972 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 1890 1450 2 0 {name=l1973 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 1890 1470 2 0 {name=l1974 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 1890 1490 2 0 {name=l1975 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 1890 1510 2 0 {name=l1976 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 1890 1530 2 0 {name=l1977 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 1890 1550 2 0 {name=l1978 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 1890 1570 2 0 {name=l1979 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 1890 1590 2 0 {name=l1980 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 1890 1610 2 0 {name=l1981 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 1680 930 1 0 {name=l1983 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1700 930 1 0 {name=l1984 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 1720 930 1 0 {name=l1985 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 1740 930 1 0 {name=l1986 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 1770 930 1 0 {name=l1987 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1790 930 1 0 {name=l1988 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 2240 1240 0 0 {name=xbyte29 NF=2}
C {lab_wire.sym} 2070 990 0 0 {name=l1989 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2070 1010 0 0 {name=l1990 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2070 1030 0 0 {name=l1991 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2070 1050 0 0 {name=l1992 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2070 1070 0 0 {name=l1993 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2070 1090 0 0 {name=l1994 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2070 1110 0 0 {name=l1995 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2070 1130 0 0 {name=l1996 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2070 1150 0 0 {name=l1997 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2070 1170 0 0 {name=l1998 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2070 1190 0 0 {name=l1999 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2070 1210 0 0 {name=l2000 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2070 1230 0 0 {name=l2001 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2070 1250 0 0 {name=l2002 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2070 1270 0 0 {name=l2003 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2070 1290 0 0 {name=l2004 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2070 1310 0 0 {name=l2005 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2070 1330 0 0 {name=l2006 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2070 1350 0 0 {name=l2007 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2070 1370 0 0 {name=l2008 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2070 1390 0 0 {name=l2009 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2070 1410 0 0 {name=l2010 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2070 1430 0 0 {name=l2011 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2070 1450 0 0 {name=l2012 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2070 1470 0 0 {name=l2013 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2070 1490 0 0 {name=l2014 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2070 1510 0 0 {name=l2015 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2070 1530 0 0 {name=l2016 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2070 1550 0 0 {name=l2017 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2070 1570 0 0 {name=l2018 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2070 1610 0 0 {name=l2019 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2070 1590 0 0 {name=l2020 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2410 990 2 0 {name=l2021 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2410 1010 2 0 {name=l2022 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2410 1030 2 0 {name=l2023 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2410 1050 2 0 {name=l2024 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2410 1070 2 0 {name=l2025 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2410 1090 2 0 {name=l2026 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2410 1110 2 0 {name=l2027 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2410 1130 2 0 {name=l2028 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2410 1150 2 0 {name=l2029 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2410 1170 2 0 {name=l2030 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2410 1190 2 0 {name=l2031 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2410 1210 2 0 {name=l2032 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2410 1230 2 0 {name=l2033 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2410 1250 2 0 {name=l2034 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2410 1270 2 0 {name=l2035 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2410 1290 2 0 {name=l2036 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2410 1310 2 0 {name=l2037 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2410 1330 2 0 {name=l2038 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2410 1350 2 0 {name=l2039 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2410 1370 2 0 {name=l2040 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2410 1390 2 0 {name=l2041 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2410 1410 2 0 {name=l2042 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2410 1430 2 0 {name=l2043 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2410 1450 2 0 {name=l2044 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2410 1470 2 0 {name=l2045 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2410 1490 2 0 {name=l2046 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2410 1510 2 0 {name=l2047 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2410 1530 2 0 {name=l2048 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2410 1550 2 0 {name=l2049 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2410 1570 2 0 {name=l2050 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2410 1590 2 0 {name=l2051 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2410 1610 2 0 {name=l2052 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2200 930 1 0 {name=l2054 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2220 930 1 0 {name=l2055 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2240 930 1 0 {name=l2056 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2260 930 1 0 {name=l2057 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2290 930 1 0 {name=l2058 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2310 930 1 0 {name=l2059 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 2760 1240 0 0 {name=xbyte30 NF=2}
C {lab_wire.sym} 2590 990 0 0 {name=l2060 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 2590 1010 0 0 {name=l2061 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 2590 1030 0 0 {name=l2062 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 2590 1050 0 0 {name=l2063 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 2590 1070 0 0 {name=l2064 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 2590 1090 0 0 {name=l2065 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 2590 1110 0 0 {name=l2066 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 2590 1130 0 0 {name=l2067 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 2590 1150 0 0 {name=l2068 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 2590 1170 0 0 {name=l2069 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 2590 1190 0 0 {name=l2070 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 2590 1210 0 0 {name=l2071 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 2590 1230 0 0 {name=l2072 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 2590 1250 0 0 {name=l2073 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 2590 1270 0 0 {name=l2074 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 2590 1290 0 0 {name=l2075 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 2590 1310 0 0 {name=l2076 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 2590 1330 0 0 {name=l2077 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2590 1350 0 0 {name=l2078 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2590 1370 0 0 {name=l2079 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2590 1390 0 0 {name=l2080 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2590 1410 0 0 {name=l2081 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2590 1430 0 0 {name=l2082 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2590 1450 0 0 {name=l2083 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2590 1470 0 0 {name=l2084 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2590 1490 0 0 {name=l2085 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2590 1510 0 0 {name=l2086 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2590 1530 0 0 {name=l2087 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2590 1550 0 0 {name=l2088 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2590 1570 0 0 {name=l2089 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2590 1610 0 0 {name=l2090 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2590 1590 0 0 {name=l2091 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2930 990 2 0 {name=l2092 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 2930 1010 2 0 {name=l2093 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 2930 1030 2 0 {name=l2094 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 2930 1050 2 0 {name=l2095 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 2930 1070 2 0 {name=l2096 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 2930 1090 2 0 {name=l2097 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 2930 1110 2 0 {name=l2098 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 2930 1130 2 0 {name=l2099 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 2930 1150 2 0 {name=l2100 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 2930 1170 2 0 {name=l2101 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 2930 1190 2 0 {name=l2102 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 2930 1210 2 0 {name=l2103 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 2930 1230 2 0 {name=l2104 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 2930 1250 2 0 {name=l2105 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 2930 1270 2 0 {name=l2106 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 2930 1290 2 0 {name=l2107 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 2930 1310 2 0 {name=l2108 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 2930 1330 2 0 {name=l2109 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 2930 1350 2 0 {name=l2110 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 2930 1370 2 0 {name=l2111 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 2930 1390 2 0 {name=l2112 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 2930 1410 2 0 {name=l2113 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 2930 1430 2 0 {name=l2114 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 2930 1450 2 0 {name=l2115 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 2930 1470 2 0 {name=l2116 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 2930 1490 2 0 {name=l2117 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 2930 1510 2 0 {name=l2118 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 2930 1530 2 0 {name=l2119 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 2930 1550 2 0 {name=l2120 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 2930 1570 2 0 {name=l2121 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 2930 1590 2 0 {name=l2122 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 2930 1610 2 0 {name=l2123 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 2720 930 1 0 {name=l2125 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2740 930 1 0 {name=l2126 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 2760 930 1 0 {name=l2127 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 2780 930 1 0 {name=l2128 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 2810 930 1 0 {name=l2129 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2830 930 1 0 {name=l2130 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 3300 1240 0 0 {name=xbyte31 NF=2}
C {lab_wire.sym} 3130 990 0 0 {name=l2131 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 3130 1010 0 0 {name=l2132 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 3130 1030 0 0 {name=l2133 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 3130 1050 0 0 {name=l2134 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 3130 1070 0 0 {name=l2135 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 3130 1090 0 0 {name=l2136 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 3130 1110 0 0 {name=l2137 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 3130 1130 0 0 {name=l2138 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 3130 1150 0 0 {name=l2139 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 3130 1170 0 0 {name=l2140 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 3130 1190 0 0 {name=l2141 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 3130 1210 0 0 {name=l2142 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 3130 1230 0 0 {name=l2143 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 3130 1250 0 0 {name=l2144 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 3130 1270 0 0 {name=l2145 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 3130 1290 0 0 {name=l2146 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 3130 1310 0 0 {name=l2147 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 3130 1330 0 0 {name=l2148 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3130 1350 0 0 {name=l2149 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3130 1370 0 0 {name=l2150 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3130 1390 0 0 {name=l2151 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3130 1410 0 0 {name=l2152 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3130 1430 0 0 {name=l2153 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3130 1450 0 0 {name=l2154 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3130 1470 0 0 {name=l2155 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3130 1490 0 0 {name=l2156 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3130 1510 0 0 {name=l2157 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3130 1530 0 0 {name=l2158 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3130 1550 0 0 {name=l2159 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3130 1570 0 0 {name=l2160 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3130 1610 0 0 {name=l2161 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3130 1590 0 0 {name=l2162 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3470 990 2 0 {name=l2163 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3470 1010 2 0 {name=l2164 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3470 1030 2 0 {name=l2165 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3470 1050 2 0 {name=l2166 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3470 1070 2 0 {name=l2167 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3470 1090 2 0 {name=l2168 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3470 1110 2 0 {name=l2169 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3470 1130 2 0 {name=l2170 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3470 1150 2 0 {name=l2171 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3470 1170 2 0 {name=l2172 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3470 1190 2 0 {name=l2173 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3470 1210 2 0 {name=l2174 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3470 1230 2 0 {name=l2175 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3470 1250 2 0 {name=l2176 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3470 1270 2 0 {name=l2177 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3470 1290 2 0 {name=l2178 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3470 1310 2 0 {name=l2179 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3470 1330 2 0 {name=l2180 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3470 1350 2 0 {name=l2181 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3470 1370 2 0 {name=l2182 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3470 1390 2 0 {name=l2183 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3470 1410 2 0 {name=l2184 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3470 1430 2 0 {name=l2185 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3470 1450 2 0 {name=l2186 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3470 1470 2 0 {name=l2187 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3470 1490 2 0 {name=l2188 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3470 1510 2 0 {name=l2189 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3470 1530 2 0 {name=l2190 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3470 1550 2 0 {name=l2191 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3470 1570 2 0 {name=l2192 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3470 1590 2 0 {name=l2193 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3470 1610 2 0 {name=l2194 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 3260 930 1 0 {name=l2196 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3280 930 1 0 {name=l2197 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 3300 930 1 0 {name=l2198 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 3320 930 1 0 {name=l2199 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 3350 930 1 0 {name=l2200 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3370 930 1 0 {name=l2201 sig_type=std_logic lab=VSS}
C {xschem_lib/word.sym} 3820 1240 0 0 {name=xbyte32 NF=2}
C {lab_wire.sym} 3650 990 0 0 {name=l2202 sig_type=std_logic lab=Di[0]}
C {lab_wire.sym} 3650 1010 0 0 {name=l2203 sig_type=std_logic lab=Di[1]}
C {lab_wire.sym} 3650 1030 0 0 {name=l2204 sig_type=std_logic lab=Di[2]}
C {lab_wire.sym} 3650 1050 0 0 {name=l2205 sig_type=std_logic lab=Di[3]}
C {lab_wire.sym} 3650 1070 0 0 {name=l2206 sig_type=std_logic lab=Di[4]}
C {lab_wire.sym} 3650 1090 0 0 {name=l2207 sig_type=std_logic lab=Di[5]}
C {lab_wire.sym} 3650 1110 0 0 {name=l2208 sig_type=std_logic lab=Di[6]}
C {lab_wire.sym} 3650 1130 0 0 {name=l2209 sig_type=std_logic lab=Di[7]}
C {lab_wire.sym} 3650 1150 0 0 {name=l2210 sig_type=std_logic lab=Di[8]}
C {lab_wire.sym} 3650 1170 0 0 {name=l2211 sig_type=std_logic lab=Di[9]}
C {lab_wire.sym} 3650 1190 0 0 {name=l2212 sig_type=std_logic lab=Di[10]}
C {lab_wire.sym} 3650 1210 0 0 {name=l2213 sig_type=std_logic lab=Di[11]}
C {lab_wire.sym} 3650 1230 0 0 {name=l2214 sig_type=std_logic lab=Di[12]}
C {lab_wire.sym} 3650 1250 0 0 {name=l2215 sig_type=std_logic lab=Di[13]}
C {lab_wire.sym} 3650 1270 0 0 {name=l2216 sig_type=std_logic lab=Di[14]}
C {lab_wire.sym} 3650 1290 0 0 {name=l2217 sig_type=std_logic lab=Di[15]}
C {lab_wire.sym} 3650 1310 0 0 {name=l2218 sig_type=std_logic lab=Di[16]}
C {lab_wire.sym} 3650 1330 0 0 {name=l2219 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3650 1350 0 0 {name=l2220 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3650 1370 0 0 {name=l2221 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3650 1390 0 0 {name=l2222 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3650 1410 0 0 {name=l2223 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3650 1430 0 0 {name=l2224 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3650 1450 0 0 {name=l2225 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3650 1470 0 0 {name=l2226 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3650 1490 0 0 {name=l2227 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3650 1510 0 0 {name=l2228 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3650 1530 0 0 {name=l2229 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3650 1550 0 0 {name=l2230 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3650 1570 0 0 {name=l2231 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3650 1610 0 0 {name=l2232 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3650 1590 0 0 {name=l2233 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3990 990 2 0 {name=l2234 sig_type=std_logic lab=Do[0]}
C {lab_wire.sym} 3990 1010 2 0 {name=l2235 sig_type=std_logic lab=Do[1]}
C {lab_wire.sym} 3990 1030 2 0 {name=l2236 sig_type=std_logic lab=Do[2]}
C {lab_wire.sym} 3990 1050 2 0 {name=l2237 sig_type=std_logic lab=Do[3]}
C {lab_wire.sym} 3990 1070 2 0 {name=l2238 sig_type=std_logic lab=Do[4]}
C {lab_wire.sym} 3990 1090 2 0 {name=l2239 sig_type=std_logic lab=Do[5]}
C {lab_wire.sym} 3990 1110 2 0 {name=l2240 sig_type=std_logic lab=Do[6]}
C {lab_wire.sym} 3990 1130 2 0 {name=l2241 sig_type=std_logic lab=Do[7]}
C {lab_wire.sym} 3990 1150 2 0 {name=l2242 sig_type=std_logic lab=Do[8]}
C {lab_wire.sym} 3990 1170 2 0 {name=l2243 sig_type=std_logic lab=Do[9]}
C {lab_wire.sym} 3990 1190 2 0 {name=l2244 sig_type=std_logic lab=Do[10]}
C {lab_wire.sym} 3990 1210 2 0 {name=l2245 sig_type=std_logic lab=Do[11]}
C {lab_wire.sym} 3990 1230 2 0 {name=l2246 sig_type=std_logic lab=Do[12]}
C {lab_wire.sym} 3990 1250 2 0 {name=l2247 sig_type=std_logic lab=Do[13]}
C {lab_wire.sym} 3990 1270 2 0 {name=l2248 sig_type=std_logic lab=Do[14]}
C {lab_wire.sym} 3990 1290 2 0 {name=l2249 sig_type=std_logic lab=Do[15]}
C {lab_wire.sym} 3990 1310 2 0 {name=l2250 sig_type=std_logic lab=Do[16]}
C {lab_wire.sym} 3990 1330 2 0 {name=l2251 sig_type=std_logic lab=Do[17]}
C {lab_wire.sym} 3990 1350 2 0 {name=l2252 sig_type=std_logic lab=Do[18]}
C {lab_wire.sym} 3990 1370 2 0 {name=l2253 sig_type=std_logic lab=Do[19]}
C {lab_wire.sym} 3990 1390 2 0 {name=l2254 sig_type=std_logic lab=Do[20]}
C {lab_wire.sym} 3990 1410 2 0 {name=l2255 sig_type=std_logic lab=Do[21]}
C {lab_wire.sym} 3990 1430 2 0 {name=l2256 sig_type=std_logic lab=Do[22]}
C {lab_wire.sym} 3990 1450 2 0 {name=l2257 sig_type=std_logic lab=Do[23]}
C {lab_wire.sym} 3990 1470 2 0 {name=l2258 sig_type=std_logic lab=Do[24]}
C {lab_wire.sym} 3990 1490 2 0 {name=l2259 sig_type=std_logic lab=Do[25]}
C {lab_wire.sym} 3990 1510 2 0 {name=l2260 sig_type=std_logic lab=Do[26]}
C {lab_wire.sym} 3990 1530 2 0 {name=l2261 sig_type=std_logic lab=Do[27]}
C {lab_wire.sym} 3990 1550 2 0 {name=l2262 sig_type=std_logic lab=Do[28]}
C {lab_wire.sym} 3990 1570 2 0 {name=l2263 sig_type=std_logic lab=Do[29]}
C {lab_wire.sym} 3990 1590 2 0 {name=l2264 sig_type=std_logic lab=Do[30]}
C {lab_wire.sym} 3990 1610 2 0 {name=l2265 sig_type=std_logic lab=Do[31]}
C {lab_wire.sym} 3780 930 1 0 {name=l2267 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3800 930 1 0 {name=l2268 sig_type=std_logic lab=WE[1]}
C {lab_wire.sym} 3820 930 1 0 {name=l2269 sig_type=std_logic lab=WE[2]}
C {lab_wire.sym} 3840 930 1 0 {name=l2270 sig_type=std_logic lab=WE[3]}
C {lab_wire.sym} 3870 930 1 0 {name=l2271 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3890 930 1 0 {name=l2272 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3210 -1820 0 0 {name=l491 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3730 -1820 0 0 {name=l562 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 50 -920 0 0 {name=l633 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 570 -920 0 0 {name=l704 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1110 -920 0 0 {name=l775 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1630 -920 0 0 {name=l846 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2150 -920 0 0 {name=l917 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2670 -920 0 0 {name=l988 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3210 -920 0 0 {name=l1059 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3730 -920 0 0 {name=l1130 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3740 30 0 0 {name=l1201 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3220 30 0 0 {name=l1272 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2680 30 0 0 {name=l1343 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2160 30 0 0 {name=l1414 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1640 30 0 0 {name=l1485 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1120 30 0 0 {name=l1556 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 580 30 0 0 {name=l1627 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 60 30 0 0 {name=l1698 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 60 930 0 0 {name=l1769 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 580 930 0 0 {name=l1840 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1120 930 0 0 {name=l1911 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1640 930 0 0 {name=l1982 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2160 930 0 0 {name=l2053 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2680 930 0 0 {name=l2124 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3220 930 0 0 {name=l2195 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3740 930 0 0 {name=l2266 sig_type=std_logic lab=CLK_buf}
C {xschem_lib/dec_2to4.sym} -1680 -1300 0 0 {name=x1 NF=2}
C {xschem_lib/dec_3to8.sym} -1250 -1680 0 0 {name=x_dec1 NF=2}
C {xschem_lib/dec_3to8.sym} -1250 -1430 0 0 {name=x_dec2 NF=2}
C {xschem_lib/dec_3to8.sym} -1250 -1180 0 0 {name=x_dec3 NF=2}
C {xschem_lib/dec_3to8.sym} -1250 -920 0 0 {name=x_dec4 NF=2}
C {ipin.sym} -1780 -1300 0 0 {name=p1 lab=A3}
C {ipin.sym} -1780 -1280 0 0 {name=p2 lab=A4}
C {ipin.sym} -1780 -1260 0 0 {name=p3 lab=EN}
C {ipin.sym} -1780 -1160 0 0 {name=p4 lab=A2}
C {ipin.sym} -1780 -1140 0 0 {name=p5 lab=A1}
C {ipin.sym} -1780 -1120 0 0 {name=p6 lab=A0}
C {lab_wire.sym} -1770 -1340 0 0 {name=l2273 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1770 -1320 0 0 {name=l2274 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1350 -1740 0 0 {name=l2275 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1350 -1720 0 0 {name=l2276 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1350 -1490 0 0 {name=l2277 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1350 -1470 0 0 {name=l2278 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1350 -1240 0 0 {name=l2279 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1350 -1220 0 0 {name=l2280 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1350 -980 0 0 {name=l2281 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1350 -960 0 0 {name=l2282 sig_type=std_logic lab=VSS}
C {xschem_lib/inv.sym} -1760 -600 0 0 {name=X_inv1 NF=12}
C {xschem_lib/inv.sym} -1600 -600 0 0 {name=X_inv2 NF=12}
C {lab_wire.sym} -1620 -680 0 0 {name=l2283 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 -600 0 0 {name=l2284 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1150 -1750 2 0 {name=l2285 sig_type=std_logic lab=Y0}
C {lab_wire.sym} -1150 -1730 2 0 {name=l2286 sig_type=std_logic lab=Y1}
C {lab_wire.sym} -1150 -1710 2 0 {name=l2287 sig_type=std_logic lab=Y2}
C {lab_wire.sym} -1150 -1690 2 0 {name=l2288 sig_type=std_logic lab=Y3}
C {lab_wire.sym} -1150 -1670 2 0 {name=l2289 sig_type=std_logic lab=Y4}
C {lab_wire.sym} -1150 -1650 2 0 {name=l2290 sig_type=std_logic lab=Y5}
C {lab_wire.sym} -1150 -1630 2 0 {name=l2291 sig_type=std_logic lab=Y6}
C {lab_wire.sym} -1150 -1610 2 0 {name=l2292 sig_type=std_logic lab=Y7}
C {lab_wire.sym} -1150 -1500 2 0 {name=l2293 sig_type=std_logic lab=Y8}
C {lab_wire.sym} -1150 -1480 2 0 {name=l2294 sig_type=std_logic lab=Y9}
C {lab_wire.sym} -1150 -1460 2 0 {name=l2295 sig_type=std_logic lab=Y10}
C {lab_wire.sym} -1150 -1440 2 0 {name=l2296 sig_type=std_logic lab=Y11}
C {lab_wire.sym} -1150 -1420 2 0 {name=l2297 sig_type=std_logic lab=Y12}
C {lab_wire.sym} -1150 -1400 2 0 {name=l2298 sig_type=std_logic lab=Y13}
C {lab_wire.sym} -1150 -1380 2 0 {name=l2299 sig_type=std_logic lab=Y14}
C {lab_wire.sym} -1150 -1360 2 0 {name=l2300 sig_type=std_logic lab=Y15}
C {lab_wire.sym} -1150 -1250 2 0 {name=l2301 sig_type=std_logic lab=Y16}
C {lab_wire.sym} -1150 -1230 2 0 {name=l2302 sig_type=std_logic lab=Y17}
C {lab_wire.sym} -1150 -1210 2 0 {name=l2303 sig_type=std_logic lab=Y18}
C {lab_wire.sym} -1150 -1190 2 0 {name=l2304 sig_type=std_logic lab=Y19}
C {lab_wire.sym} -1150 -1170 2 0 {name=l2305 sig_type=std_logic lab=Y20}
C {lab_wire.sym} -1150 -1150 2 0 {name=l2306 sig_type=std_logic lab=Y21}
C {lab_wire.sym} -1150 -1130 2 0 {name=l2307 sig_type=std_logic lab=Y22}
C {lab_wire.sym} -1150 -1110 2 0 {name=l2308 sig_type=std_logic lab=Y23}
C {lab_wire.sym} -1150 -990 2 0 {name=l2309 sig_type=std_logic lab=Y24}
C {lab_wire.sym} -1150 -970 2 0 {name=l2310 sig_type=std_logic lab=Y25}
C {lab_wire.sym} -1150 -950 2 0 {name=l2311 sig_type=std_logic lab=Y26}
C {lab_wire.sym} -1150 -930 2 0 {name=l2312 sig_type=std_logic lab=Y27}
C {lab_wire.sym} -1150 -910 2 0 {name=l2313 sig_type=std_logic lab=Y28}
C {lab_wire.sym} -1150 -890 2 0 {name=l2314 sig_type=std_logic lab=Y29}
C {lab_wire.sym} -1150 -870 2 0 {name=l2315 sig_type=std_logic lab=Y30}
C {lab_wire.sym} -1150 -850 2 0 {name=l2316 sig_type=std_logic lab=Y31}
C {lab_wire.sym} -1770 -640 0 0 {name=l2317 sig_type=std_logic lab=Y0}
C {lab_wire.sym} -1440 -640 0 0 {name=l2318 sig_type=std_logic lab=SEL[0]}
C {xschem_lib/inv.sym} -1400 -600 0 0 {name=X_inv3 NF=12}
C {xschem_lib/inv.sym} -1240 -600 0 0 {name=X_inv4 NF=12}
C {lab_wire.sym} -1260 -680 0 0 {name=l2319 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1260 -600 0 0 {name=l2320 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1410 -640 0 0 {name=l2321 sig_type=std_logic lab=Y1}
C {lab_wire.sym} -1080 -640 0 0 {name=l2322 sig_type=std_logic lab=SEL[1]}
C {xschem_lib/inv.sym} -1020 -600 0 0 {name=X_inv5 NF=12}
C {xschem_lib/inv.sym} -860 -600 0 0 {name=X_inv6 NF=12}
C {lab_wire.sym} -880 -680 0 0 {name=l2323 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -880 -600 0 0 {name=l2324 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1030 -640 0 0 {name=l2325 sig_type=std_logic lab=Y2}
C {lab_wire.sym} -700 -640 0 0 {name=l2326 sig_type=std_logic lab=SEL[2]}
C {xschem_lib/inv.sym} -660 -600 0 0 {name=X_inv7 NF=12}
C {xschem_lib/inv.sym} -500 -600 0 0 {name=X_inv8 NF=12}
C {lab_wire.sym} -520 -680 0 0 {name=l2327 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -520 -600 0 0 {name=l2328 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -670 -640 0 0 {name=l2329 sig_type=std_logic lab=Y3}
C {lab_wire.sym} -340 -640 0 0 {name=l2330 sig_type=std_logic lab=SEL[3]}
C {xschem_lib/inv.sym} -1760 -430 0 0 {name=X_inv9 NF=12}
C {xschem_lib/inv.sym} -1600 -430 0 0 {name=X_inv10 NF=12}
C {lab_wire.sym} -1620 -510 0 0 {name=l2331 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 -430 0 0 {name=l2332 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 -470 0 0 {name=l2333 sig_type=std_logic lab=Y4}
C {lab_wire.sym} -1440 -470 0 0 {name=l2334 sig_type=std_logic lab=SEL[4]}
C {xschem_lib/inv.sym} -1400 -430 0 0 {name=X_inv11 NF=12}
C {xschem_lib/inv.sym} -1240 -430 0 0 {name=X_inv12 NF=12}
C {lab_wire.sym} -1260 -510 0 0 {name=l2335 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1260 -430 0 0 {name=l2336 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1410 -470 0 0 {name=l2337 sig_type=std_logic lab=Y5}
C {lab_wire.sym} -1080 -470 0 0 {name=l2338 sig_type=std_logic lab=SEL[5]}
C {xschem_lib/inv.sym} -1020 -430 0 0 {name=X_inv13 NF=12}
C {xschem_lib/inv.sym} -860 -430 0 0 {name=X_inv14 NF=12}
C {lab_wire.sym} -880 -510 0 0 {name=l2339 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -880 -430 0 0 {name=l2340 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1030 -470 0 0 {name=l2341 sig_type=std_logic lab=Y6}
C {lab_wire.sym} -700 -470 0 0 {name=l2342 sig_type=std_logic lab=SEL[6]}
C {xschem_lib/inv.sym} -660 -430 0 0 {name=X_inv15 NF=12}
C {xschem_lib/inv.sym} -500 -430 0 0 {name=X_inv16 NF=12}
C {lab_wire.sym} -520 -510 0 0 {name=l2343 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -520 -430 0 0 {name=l2344 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -670 -470 0 0 {name=l2345 sig_type=std_logic lab=Y7}
C {lab_wire.sym} -340 -470 0 0 {name=l2346 sig_type=std_logic lab=SEL[7]}
C {xschem_lib/inv.sym} -1770 -260 0 0 {name=X_inv17 NF=12}
C {xschem_lib/inv.sym} -1610 -260 0 0 {name=X_inv18 NF=12}
C {lab_wire.sym} -1630 -340 0 0 {name=l2347 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1630 -260 0 0 {name=l2348 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1780 -300 0 0 {name=l2349 sig_type=std_logic lab=Y8}
C {lab_wire.sym} -1450 -300 0 0 {name=l2350 sig_type=std_logic lab=SEL[8]}
C {xschem_lib/inv.sym} -1410 -260 0 0 {name=X_inv19 NF=12}
C {xschem_lib/inv.sym} -1250 -260 0 0 {name=X_inv20 NF=12}
C {lab_wire.sym} -1270 -340 0 0 {name=l2351 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1270 -260 0 0 {name=l2352 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1420 -300 0 0 {name=l2353 sig_type=std_logic lab=Y9}
C {lab_wire.sym} -1090 -300 0 0 {name=l2354 sig_type=std_logic lab=SEL[9]}
C {xschem_lib/inv.sym} -1030 -260 0 0 {name=X_inv21 NF=12}
C {xschem_lib/inv.sym} -870 -260 0 0 {name=X_inv22 NF=12}
C {lab_wire.sym} -890 -340 0 0 {name=l2355 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -890 -260 0 0 {name=l2356 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1040 -300 0 0 {name=l2357 sig_type=std_logic lab=Y10}
C {lab_wire.sym} -710 -300 0 0 {name=l2358 sig_type=std_logic lab=SEL[10]}
C {xschem_lib/inv.sym} -670 -260 0 0 {name=X_inv23 NF=12}
C {xschem_lib/inv.sym} -510 -260 0 0 {name=X_inv24 NF=12}
C {lab_wire.sym} -530 -340 0 0 {name=l2359 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -530 -260 0 0 {name=l2360 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -680 -300 0 0 {name=l2361 sig_type=std_logic lab=Y11}
C {lab_wire.sym} -350 -300 0 0 {name=l2362 sig_type=std_logic lab=SEL[11]}
C {xschem_lib/inv.sym} -1770 -90 0 0 {name=X_inv25 NF=12}
C {xschem_lib/inv.sym} -1610 -90 0 0 {name=X_inv26 NF=12}
C {lab_wire.sym} -1630 -170 0 0 {name=l2363 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1630 -90 0 0 {name=l2364 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1780 -130 0 0 {name=l2365 sig_type=std_logic lab=Y12}
C {lab_wire.sym} -1450 -130 0 0 {name=l2366 sig_type=std_logic lab=SEL[12]}
C {xschem_lib/inv.sym} -1410 -90 0 0 {name=X_inv27 NF=12}
C {xschem_lib/inv.sym} -1250 -90 0 0 {name=X_inv28 NF=12}
C {lab_wire.sym} -1270 -170 0 0 {name=l2367 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1270 -90 0 0 {name=l2368 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1420 -130 0 0 {name=l2369 sig_type=std_logic lab=Y13}
C {lab_wire.sym} -1090 -130 0 0 {name=l2370 sig_type=std_logic lab=SEL[13]}
C {xschem_lib/inv.sym} -1030 -90 0 0 {name=X_inv29 NF=12}
C {xschem_lib/inv.sym} -870 -90 0 0 {name=X_inv30 NF=12}
C {lab_wire.sym} -890 -170 0 0 {name=l2371 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -890 -90 0 0 {name=l2372 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1040 -130 0 0 {name=l2373 sig_type=std_logic lab=Y14}
C {lab_wire.sym} -710 -130 0 0 {name=l2374 sig_type=std_logic lab=SEL[14]}
C {xschem_lib/inv.sym} -670 -90 0 0 {name=X_inv31 NF=12}
C {xschem_lib/inv.sym} -510 -90 0 0 {name=X_inv32 NF=12}
C {lab_wire.sym} -530 -170 0 0 {name=l2375 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -530 -90 0 0 {name=l2376 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -680 -130 0 0 {name=l2377 sig_type=std_logic lab=Y15}
C {lab_wire.sym} -350 -130 0 0 {name=l2378 sig_type=std_logic lab=SEL[15]}
C {xschem_lib/inv.sym} -1760 80 0 0 {name=X_inv33 NF=12}
C {xschem_lib/inv.sym} -1600 80 0 0 {name=X_inv34 NF=12}
C {lab_wire.sym} -1620 0 0 0 {name=l2379 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 80 0 0 {name=l2380 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 40 0 0 {name=l2381 sig_type=std_logic lab=Y16}
C {lab_wire.sym} -1440 40 0 0 {name=l2382 sig_type=std_logic lab=SEL[16]}
C {xschem_lib/inv.sym} -1400 80 0 0 {name=X_inv35 NF=12}
C {xschem_lib/inv.sym} -1240 80 0 0 {name=X_inv36 NF=12}
C {lab_wire.sym} -1260 0 0 0 {name=l2383 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1260 80 0 0 {name=l2384 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1410 40 0 0 {name=l2385 sig_type=std_logic lab=Y17}
C {lab_wire.sym} -1080 40 0 0 {name=l2386 sig_type=std_logic lab=SEL[17]}
C {xschem_lib/inv.sym} -1020 80 0 0 {name=X_inv37 NF=12}
C {xschem_lib/inv.sym} -860 80 0 0 {name=X_inv38 NF=12}
C {lab_wire.sym} -880 0 0 0 {name=l2387 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -880 80 0 0 {name=l2388 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1030 40 0 0 {name=l2389 sig_type=std_logic lab=Y18}
C {lab_wire.sym} -700 40 0 0 {name=l2390 sig_type=std_logic lab=SEL[18]}
C {xschem_lib/inv.sym} -660 80 0 0 {name=X_inv39 NF=12}
C {xschem_lib/inv.sym} -500 80 0 0 {name=X_inv40 NF=12}
C {lab_wire.sym} -520 0 0 0 {name=l2391 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -520 80 0 0 {name=l2392 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -670 40 0 0 {name=l2393 sig_type=std_logic lab=Y19}
C {lab_wire.sym} -340 40 0 0 {name=l2394 sig_type=std_logic lab=SEL[19]}
C {xschem_lib/inv.sym} -1760 250 0 0 {name=X_inv41 NF=12}
C {xschem_lib/inv.sym} -1600 250 0 0 {name=X_inv42 NF=12}
C {lab_wire.sym} -1620 170 0 0 {name=l2395 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 250 0 0 {name=l2396 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 210 0 0 {name=l2397 sig_type=std_logic lab=Y20}
C {lab_wire.sym} -1440 210 0 0 {name=l2398 sig_type=std_logic lab=SEL[20]}
C {xschem_lib/inv.sym} -1400 250 0 0 {name=X_inv43 NF=12}
C {xschem_lib/inv.sym} -1240 250 0 0 {name=X_inv44 NF=12}
C {lab_wire.sym} -1260 170 0 0 {name=l2399 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1260 250 0 0 {name=l2400 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1410 210 0 0 {name=l2401 sig_type=std_logic lab=Y21}
C {lab_wire.sym} -1080 210 0 0 {name=l2402 sig_type=std_logic lab=SEL[21]}
C {xschem_lib/inv.sym} -1020 250 0 0 {name=X_inv45 NF=12}
C {xschem_lib/inv.sym} -860 250 0 0 {name=X_inv46 NF=12}
C {lab_wire.sym} -880 170 0 0 {name=l2403 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -880 250 0 0 {name=l2404 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1030 210 0 0 {name=l2405 sig_type=std_logic lab=Y22}
C {lab_wire.sym} -700 210 0 0 {name=l2406 sig_type=std_logic lab=SEL[22]}
C {xschem_lib/inv.sym} -660 250 0 0 {name=X_inv47 NF=12}
C {xschem_lib/inv.sym} -500 250 0 0 {name=X_inv48 NF=12}
C {lab_wire.sym} -520 170 0 0 {name=l2407 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -520 250 0 0 {name=l2408 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -670 210 0 0 {name=l2409 sig_type=std_logic lab=Y23}
C {lab_wire.sym} -340 210 0 0 {name=l2410 sig_type=std_logic lab=SEL[23]}
C {xschem_lib/inv.sym} -1760 420 0 0 {name=X_inv49 NF=12}
C {xschem_lib/inv.sym} -1600 420 0 0 {name=X_inv50 NF=12}
C {lab_wire.sym} -1620 340 0 0 {name=l2411 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 420 0 0 {name=l2412 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 380 0 0 {name=l2413 sig_type=std_logic lab=Y24}
C {lab_wire.sym} -1440 380 0 0 {name=l2414 sig_type=std_logic lab=SEL[24]}
C {xschem_lib/inv.sym} -1400 420 0 0 {name=X_inv51 NF=12}
C {xschem_lib/inv.sym} -1240 420 0 0 {name=X_inv52 NF=12}
C {lab_wire.sym} -1260 340 0 0 {name=l2415 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1260 420 0 0 {name=l2416 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1410 380 0 0 {name=l2417 sig_type=std_logic lab=Y25}
C {lab_wire.sym} -1080 380 0 0 {name=l2418 sig_type=std_logic lab=SEL[25]}
C {xschem_lib/inv.sym} -1020 420 0 0 {name=X_inv53 NF=12}
C {xschem_lib/inv.sym} -860 420 0 0 {name=X_inv54 NF=12}
C {lab_wire.sym} -880 340 0 0 {name=l2419 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -880 420 0 0 {name=l2420 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1030 380 0 0 {name=l2421 sig_type=std_logic lab=Y26}
C {lab_wire.sym} -700 380 0 0 {name=l2422 sig_type=std_logic lab=SEL[26]}
C {xschem_lib/inv.sym} -660 420 0 0 {name=X_inv55 NF=12}
C {xschem_lib/inv.sym} -500 420 0 0 {name=X_inv56 NF=12}
C {lab_wire.sym} -520 340 0 0 {name=l2423 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -520 420 0 0 {name=l2424 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -670 380 0 0 {name=l2425 sig_type=std_logic lab=Y27}
C {lab_wire.sym} -340 380 0 0 {name=l2426 sig_type=std_logic lab=SEL[27]}
C {xschem_lib/inv.sym} -1760 590 0 0 {name=X_inv57 NF=12}
C {xschem_lib/inv.sym} -1600 590 0 0 {name=X_inv58 NF=12}
C {lab_wire.sym} -1620 510 0 0 {name=l2427 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 590 0 0 {name=l2428 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 550 0 0 {name=l2429 sig_type=std_logic lab=Y28}
C {lab_wire.sym} -1440 550 0 0 {name=l2430 sig_type=std_logic lab=SEL[28]}
C {xschem_lib/inv.sym} -1400 590 0 0 {name=X_inv59 NF=12}
C {xschem_lib/inv.sym} -1240 590 0 0 {name=X_inv60 NF=12}
C {lab_wire.sym} -1260 510 0 0 {name=l2431 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1260 590 0 0 {name=l2432 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1410 550 0 0 {name=l2433 sig_type=std_logic lab=Y29}
C {lab_wire.sym} -1080 550 0 0 {name=l2434 sig_type=std_logic lab=SEL[29]}
C {xschem_lib/inv.sym} -1020 590 0 0 {name=X_inv61 NF=12}
C {xschem_lib/inv.sym} -860 590 0 0 {name=X_inv62 NF=12}
C {lab_wire.sym} -880 510 0 0 {name=l2435 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -880 590 0 0 {name=l2436 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1030 550 0 0 {name=l2437 sig_type=std_logic lab=Y30}
C {lab_wire.sym} -700 550 0 0 {name=l2438 sig_type=std_logic lab=SEL[30]}
C {xschem_lib/inv.sym} -660 590 0 0 {name=X_inv63 NF=12}
C {xschem_lib/inv.sym} -500 590 0 0 {name=X_inv64 NF=12}
C {lab_wire.sym} -520 510 0 0 {name=l2439 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -520 590 0 0 {name=l2440 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -670 550 0 0 {name=l2441 sig_type=std_logic lab=Y31}
C {lab_wire.sym} -340 550 0 0 {name=l2442 sig_type=std_logic lab=SEL[31]}
C {lab_wire.sym} 70 -920 1 0 {name=l2443 sig_type=std_logic lab=SEL[8]}
C {lab_wire.sym} 70 -1820 1 0 {name=l2444 sig_type=std_logic lab=SEL[0]}
C {lab_wire.sym} 80 30 1 0 {name=l2445 sig_type=std_logic lab=SEL[16]}
C {lab_wire.sym} 80 930 1 0 {name=l2446 sig_type=std_logic lab=SEL[24]}
C {lab_wire.sym} 610 -1820 1 0 {name=l2447 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 610 -920 1 0 {name=l2448 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 590 -920 1 0 {name=l2449 sig_type=std_logic lab=SEL[9]}
C {lab_wire.sym} 590 -1820 1 0 {name=l2450 sig_type=std_logic lab=SEL[1]}
C {lab_wire.sym} 600 30 1 0 {name=l2451 sig_type=std_logic lab=SEL[17]}
C {lab_wire.sym} 600 930 1 0 {name=l2452 sig_type=std_logic lab=SEL[25]}
C {lab_wire.sym} 1150 -1820 1 0 {name=l2453 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1150 -920 1 0 {name=l2454 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1130 -920 1 0 {name=l2455 sig_type=std_logic lab=SEL[10]}
C {lab_wire.sym} 1130 -1820 1 0 {name=l2456 sig_type=std_logic lab=SEL[2]}
C {lab_wire.sym} 1140 30 1 0 {name=l2457 sig_type=std_logic lab=SEL[18]}
C {lab_wire.sym} 1140 930 1 0 {name=l2458 sig_type=std_logic lab=SEL[26]}
C {lab_wire.sym} 1670 -1820 1 0 {name=l2459 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1670 -920 1 0 {name=l2460 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 1650 -920 1 0 {name=l2461 sig_type=std_logic lab=SEL[11]}
C {lab_wire.sym} 1650 -1820 1 0 {name=l2462 sig_type=std_logic lab=SEL[3]}
C {lab_wire.sym} 1660 30 1 0 {name=l2463 sig_type=std_logic lab=SEL[19]}
C {lab_wire.sym} 1660 930 1 0 {name=l2464 sig_type=std_logic lab=SEL[27]}
C {lab_wire.sym} 2190 -1820 1 0 {name=l2465 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2190 -920 1 0 {name=l2466 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2170 -920 1 0 {name=l2467 sig_type=std_logic lab=SEL[12]}
C {lab_wire.sym} 2170 -1820 1 0 {name=l2468 sig_type=std_logic lab=SEL[4]}
C {lab_wire.sym} 2180 30 1 0 {name=l2469 sig_type=std_logic lab=SEL[20]}
C {lab_wire.sym} 2180 930 1 0 {name=l2470 sig_type=std_logic lab=SEL[28]}
C {lab_wire.sym} 2710 -1820 1 0 {name=l2471 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2710 -920 1 0 {name=l2472 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 2690 -920 1 0 {name=l2473 sig_type=std_logic lab=SEL[13]}
C {lab_wire.sym} 2690 -1820 1 0 {name=l2474 sig_type=std_logic lab=SEL[5]}
C {lab_wire.sym} 2700 30 1 0 {name=l2475 sig_type=std_logic lab=SEL[21]}
C {lab_wire.sym} 2700 930 1 0 {name=l2476 sig_type=std_logic lab=SEL[29]}
C {lab_wire.sym} 3250 -1820 1 0 {name=l2477 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3250 -920 1 0 {name=l2478 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3230 -920 1 0 {name=l2479 sig_type=std_logic lab=SEL[14]}
C {lab_wire.sym} 3230 -1820 1 0 {name=l2480 sig_type=std_logic lab=SEL[6]}
C {lab_wire.sym} 3240 30 1 0 {name=l2481 sig_type=std_logic lab=SEL[22]}
C {lab_wire.sym} 3240 930 1 0 {name=l2482 sig_type=std_logic lab=SEL[30]}
C {lab_wire.sym} 3770 -1820 1 0 {name=l2483 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3770 -920 1 0 {name=l2484 sig_type=std_logic lab=WE[0]}
C {lab_wire.sym} 3750 -920 1 0 {name=l2485 sig_type=std_logic lab=SEL[15]}
C {lab_wire.sym} 3750 -1820 1 0 {name=l2486 sig_type=std_logic lab=SEL[7]}
C {lab_wire.sym} 3760 30 1 0 {name=l2487 sig_type=std_logic lab=SEL[23]}
C {lab_wire.sym} 3760 930 1 0 {name=l2488 sig_type=std_logic lab=SEL[31]}
C {xschem_lib/inv.sym} -1770 -1950 0 0 {name=X_inv65 NF=8}
C {xschem_lib/inv.sym} -1610 -1950 0 0 {name=X_inv66 NF=16}
C {lab_wire.sym} -1710 -2040 0 0 {name=l2489 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1710 -1940 2 0 {name=l2490 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2110 -1990 0 0 {name=l2491 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1120 -1990 2 0 {name=l2492 sig_type=std_logic lab=CLK_buf}
C {xschem_lib/inv.sym} -940 -1060 0 0 {name=X_inv67 NF=12}
C {xschem_lib/inv.sym} -780 -1060 0 0 {name=X_inv68 NF=12}
C {lab_wire.sym} -800 -1140 0 0 {name=l2493 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -800 -1060 0 0 {name=l2494 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -950 -1100 0 0 {name=l2495 sig_type=std_logic lab=WE3}
C {lab_wire.sym} -620 -1100 0 0 {name=l2496 sig_type=std_logic lab=WE[3]}
C {xschem_lib/inv.sym} -940 -1180 0 0 {name=X_inv69 NF=12}
C {xschem_lib/inv.sym} -780 -1180 0 0 {name=X_inv70 NF=12}
C {lab_wire.sym} -800 -1260 0 0 {name=l2497 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -800 -1180 0 0 {name=l2498 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -950 -1220 0 0 {name=l2499 sig_type=std_logic lab=WE2}
C {lab_wire.sym} -620 -1220 0 0 {name=l2500 sig_type=std_logic lab=WE[2]}
C {xschem_lib/inv.sym} -940 -1310 0 0 {name=X_inv71 NF=12}
C {xschem_lib/inv.sym} -780 -1310 0 0 {name=X_inv72 NF=12}
C {lab_wire.sym} -800 -1390 0 0 {name=l2501 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -800 -1310 0 0 {name=l2502 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -950 -1350 0 0 {name=l2503 sig_type=std_logic lab=WE1}
C {lab_wire.sym} -620 -1350 0 0 {name=l2504 sig_type=std_logic lab=WE[1]}
C {xschem_lib/inv.sym} -940 -1430 0 0 {name=X_inv73 NF=12}
C {xschem_lib/inv.sym} -780 -1430 0 0 {name=X_inv74 NF=12}
C {lab_wire.sym} -800 -1510 0 0 {name=l2505 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -800 -1430 0 0 {name=l2506 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -950 -1470 0 0 {name=l2507 sig_type=std_logic lab=WE0}
C {lab_wire.sym} -620 -1470 0 0 {name=l2508 sig_type=std_logic lab=WE[0]}
C {xschem_lib/inv.sym} -1760 880 0 0 {name=X_inv75 NF=14}
C {xschem_lib/inv.sym} -1600 880 0 0 {name=X_inv76 NF=14}
C {lab_wire.sym} -1620 800 0 0 {name=l2509 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 880 0 0 {name=l2510 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 840 0 0 {name=l2511 sig_type=std_logic lab=Di<0>}
C {lab_wire.sym} -1440 840 0 0 {name=l2512 sig_type=std_logic lab=Di[0]}
C {xschem_lib/inv.sym} -1360 880 0 0 {name=X_inv77 NF=14}
C {xschem_lib/inv.sym} -1200 880 0 0 {name=X_inv78 NF=14}
C {lab_wire.sym} -1220 800 0 0 {name=l2513 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 880 0 0 {name=l2514 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1370 840 0 0 {name=l2515 sig_type=std_logic lab=Di<1>}
C {lab_wire.sym} -1040 840 0 0 {name=l2516 sig_type=std_logic lab=Di[1]}
C {xschem_lib/inv.sym} -960 880 0 0 {name=X_inv79 NF=14}
C {xschem_lib/inv.sym} -800 880 0 0 {name=X_inv80 NF=14}
C {lab_wire.sym} -820 800 0 0 {name=l2517 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -820 880 0 0 {name=l2518 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -970 840 0 0 {name=l2519 sig_type=std_logic lab=Di<2>}
C {lab_wire.sym} -640 840 0 0 {name=l2520 sig_type=std_logic lab=Di[2]}
C {xschem_lib/inv.sym} -560 880 0 0 {name=X_inv81 NF=14}
C {xschem_lib/inv.sym} -400 880 0 0 {name=X_inv82 NF=14}
C {lab_wire.sym} -420 800 0 0 {name=l2521 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -420 880 0 0 {name=l2522 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -570 840 0 0 {name=l2523 sig_type=std_logic lab=Di<3>}
C {lab_wire.sym} -240 840 0 0 {name=l2524 sig_type=std_logic lab=Di[3]}
C {xschem_lib/inv.sym} -1760 1010 0 0 {name=X_inv83 NF=14}
C {xschem_lib/inv.sym} -1600 1010 0 0 {name=X_inv84 NF=14}
C {lab_wire.sym} -1620 930 0 0 {name=l2525 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 1010 0 0 {name=l2526 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 970 0 0 {name=l2527 sig_type=std_logic lab=Di<4>}
C {lab_wire.sym} -1440 970 0 0 {name=l2528 sig_type=std_logic lab=Di[4]}
C {xschem_lib/inv.sym} -1360 1010 0 0 {name=X_inv85 NF=14}
C {xschem_lib/inv.sym} -1200 1010 0 0 {name=X_inv86 NF=14}
C {lab_wire.sym} -1220 930 0 0 {name=l2529 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 1010 0 0 {name=l2530 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1370 970 0 0 {name=l2531 sig_type=std_logic lab=Di<5>}
C {lab_wire.sym} -1040 970 0 0 {name=l2532 sig_type=std_logic lab=Di[5]}
C {xschem_lib/inv.sym} -960 1010 0 0 {name=X_inv87 NF=14}
C {xschem_lib/inv.sym} -800 1010 0 0 {name=X_inv88 NF=14}
C {lab_wire.sym} -820 930 0 0 {name=l2533 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -820 1010 0 0 {name=l2534 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -970 970 0 0 {name=l2535 sig_type=std_logic lab=Di<6>}
C {lab_wire.sym} -640 970 0 0 {name=l2536 sig_type=std_logic lab=Di[6]}
C {xschem_lib/inv.sym} -560 1010 0 0 {name=X_inv89 NF=14}
C {xschem_lib/inv.sym} -400 1010 0 0 {name=X_inv90 NF=14}
C {lab_wire.sym} -420 930 0 0 {name=l2537 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -420 1010 0 0 {name=l2538 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -570 970 0 0 {name=l2539 sig_type=std_logic lab=Di<7>}
C {lab_wire.sym} -240 970 0 0 {name=l2540 sig_type=std_logic lab=Di[7]}
C {xschem_lib/inv.sym} -1760 1140 0 0 {name=X_inv91 NF=14}
C {xschem_lib/inv.sym} -1600 1140 0 0 {name=X_inv92 NF=14}
C {lab_wire.sym} -1620 1060 0 0 {name=l2541 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 1140 0 0 {name=l2542 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 1100 0 0 {name=l2543 sig_type=std_logic lab=Di<8>}
C {lab_wire.sym} -1440 1100 0 0 {name=l2544 sig_type=std_logic lab=Di[8]}
C {xschem_lib/inv.sym} -1360 1140 0 0 {name=X_inv93 NF=14}
C {xschem_lib/inv.sym} -1200 1140 0 0 {name=X_inv94 NF=14}
C {lab_wire.sym} -1220 1060 0 0 {name=l2545 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 1140 0 0 {name=l2546 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1370 1100 0 0 {name=l2547 sig_type=std_logic lab=Di<9>}
C {lab_wire.sym} -1040 1100 0 0 {name=l2548 sig_type=std_logic lab=Di[9]}
C {xschem_lib/inv.sym} -960 1140 0 0 {name=X_inv95 NF=14}
C {xschem_lib/inv.sym} -800 1140 0 0 {name=X_inv96 NF=14}
C {lab_wire.sym} -820 1060 0 0 {name=l2549 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -820 1140 0 0 {name=l2550 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -970 1100 0 0 {name=l2551 sig_type=std_logic lab=Di<10>}
C {lab_wire.sym} -640 1100 0 0 {name=l2552 sig_type=std_logic lab=Di[10]}
C {xschem_lib/inv.sym} -560 1140 0 0 {name=X_inv97 NF=14}
C {xschem_lib/inv.sym} -400 1140 0 0 {name=X_inv98 NF=14}
C {lab_wire.sym} -420 1060 0 0 {name=l2553 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -420 1140 0 0 {name=l2554 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -570 1100 0 0 {name=l2555 sig_type=std_logic lab=Di<11>}
C {lab_wire.sym} -240 1100 0 0 {name=l2556 sig_type=std_logic lab=Di[11]}
C {xschem_lib/inv.sym} -1760 1270 0 0 {name=X_inv99 NF=14}
C {xschem_lib/inv.sym} -1600 1270 0 0 {name=X_inv100 NF=14}
C {lab_wire.sym} -1620 1190 0 0 {name=l2557 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 1270 0 0 {name=l2558 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 1230 0 0 {name=l2559 sig_type=std_logic lab=Di<12>}
C {lab_wire.sym} -1440 1230 0 0 {name=l2560 sig_type=std_logic lab=Di[12]}
C {xschem_lib/inv.sym} -1360 1270 0 0 {name=X_inv101 NF=14}
C {xschem_lib/inv.sym} -1200 1270 0 0 {name=X_inv102 NF=14}
C {lab_wire.sym} -1220 1190 0 0 {name=l2561 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 1270 0 0 {name=l2562 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1370 1230 0 0 {name=l2563 sig_type=std_logic lab=Di<13>}
C {lab_wire.sym} -1040 1230 0 0 {name=l2564 sig_type=std_logic lab=Di[13]}
C {xschem_lib/inv.sym} -960 1270 0 0 {name=X_inv103 NF=14}
C {xschem_lib/inv.sym} -800 1270 0 0 {name=X_inv104 NF=14}
C {lab_wire.sym} -820 1190 0 0 {name=l2565 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -820 1270 0 0 {name=l2566 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -970 1230 0 0 {name=l2567 sig_type=std_logic lab=Di<14>}
C {lab_wire.sym} -640 1230 0 0 {name=l2568 sig_type=std_logic lab=Di[14]}
C {xschem_lib/inv.sym} -560 1270 0 0 {name=X_inv105 NF=14}
C {xschem_lib/inv.sym} -400 1270 0 0 {name=X_inv106 NF=14}
C {lab_wire.sym} -420 1190 0 0 {name=l2569 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -420 1270 0 0 {name=l2570 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -570 1230 0 0 {name=l2571 sig_type=std_logic lab=Di<15>}
C {lab_wire.sym} -240 1230 0 0 {name=l2572 sig_type=std_logic lab=Di[15]}
C {xschem_lib/inv.sym} -1760 1400 0 0 {name=X_inv107 NF=14}
C {xschem_lib/inv.sym} -1600 1400 0 0 {name=X_inv108 NF=14}
C {lab_wire.sym} -1620 1320 0 0 {name=l2573 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 1400 0 0 {name=l2574 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 1360 0 0 {name=l2575 sig_type=std_logic lab=Di<16>}
C {lab_wire.sym} -1440 1360 0 0 {name=l2576 sig_type=std_logic lab=Di[16]}
C {xschem_lib/inv.sym} -1360 1400 0 0 {name=X_inv109 NF=14}
C {xschem_lib/inv.sym} -1200 1400 0 0 {name=X_inv110 NF=14}
C {lab_wire.sym} -1220 1320 0 0 {name=l2577 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 1400 0 0 {name=l2578 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1370 1360 0 0 {name=l2579 sig_type=std_logic lab=Di<17>}
C {lab_wire.sym} -1040 1360 0 0 {name=l2580 sig_type=std_logic lab=Di[17]}
C {xschem_lib/inv.sym} -960 1400 0 0 {name=X_inv111 NF=14}
C {xschem_lib/inv.sym} -800 1400 0 0 {name=X_inv112 NF=14}
C {lab_wire.sym} -820 1320 0 0 {name=l2581 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -820 1400 0 0 {name=l2582 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -970 1360 0 0 {name=l2583 sig_type=std_logic lab=Di<18>}
C {lab_wire.sym} -640 1360 0 0 {name=l2584 sig_type=std_logic lab=Di[18]}
C {xschem_lib/inv.sym} -560 1400 0 0 {name=X_inv113 NF=14}
C {xschem_lib/inv.sym} -400 1400 0 0 {name=X_inv114 NF=14}
C {lab_wire.sym} -420 1320 0 0 {name=l2585 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -420 1400 0 0 {name=l2586 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -570 1360 0 0 {name=l2587 sig_type=std_logic lab=Di<19>}
C {lab_wire.sym} -240 1360 0 0 {name=l2588 sig_type=std_logic lab=Di[19]}
C {xschem_lib/inv.sym} -1760 1530 0 0 {name=X_inv115 NF=14}
C {xschem_lib/inv.sym} -1600 1530 0 0 {name=X_inv116 NF=14}
C {lab_wire.sym} -1620 1450 0 0 {name=l2589 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 1530 0 0 {name=l2590 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 1490 0 0 {name=l2591 sig_type=std_logic lab=Di<20>}
C {lab_wire.sym} -1440 1490 0 0 {name=l2592 sig_type=std_logic lab=Di[20]}
C {xschem_lib/inv.sym} -1360 1530 0 0 {name=X_inv117 NF=14}
C {xschem_lib/inv.sym} -1200 1530 0 0 {name=X_inv118 NF=14}
C {lab_wire.sym} -1220 1450 0 0 {name=l2593 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 1530 0 0 {name=l2594 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1370 1490 0 0 {name=l2595 sig_type=std_logic lab=Di<21>}
C {lab_wire.sym} -1040 1490 0 0 {name=l2596 sig_type=std_logic lab=Di[21]}
C {xschem_lib/inv.sym} -960 1530 0 0 {name=X_inv119 NF=14}
C {xschem_lib/inv.sym} -800 1530 0 0 {name=X_inv120 NF=14}
C {lab_wire.sym} -820 1450 0 0 {name=l2597 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -820 1530 0 0 {name=l2598 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -970 1490 0 0 {name=l2599 sig_type=std_logic lab=Di<22>}
C {lab_wire.sym} -640 1490 0 0 {name=l2600 sig_type=std_logic lab=Di[22]}
C {xschem_lib/inv.sym} -560 1530 0 0 {name=X_inv121 NF=14}
C {xschem_lib/inv.sym} -400 1530 0 0 {name=X_inv122 NF=14}
C {lab_wire.sym} -420 1450 0 0 {name=l2601 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -420 1530 0 0 {name=l2602 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -570 1490 0 0 {name=l2603 sig_type=std_logic lab=Di<23>}
C {lab_wire.sym} -240 1490 0 0 {name=l2604 sig_type=std_logic lab=Di[23]}
C {xschem_lib/inv.sym} -1760 1660 0 0 {name=X_inv123 NF=14}
C {xschem_lib/inv.sym} -1600 1660 0 0 {name=X_inv124 NF=14}
C {lab_wire.sym} -1620 1580 0 0 {name=l2605 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 1660 0 0 {name=l2606 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 1620 0 0 {name=l2607 sig_type=std_logic lab=Di<24>}
C {lab_wire.sym} -1440 1620 0 0 {name=l2608 sig_type=std_logic lab=Di[24]}
C {xschem_lib/inv.sym} -1360 1660 0 0 {name=X_inv125 NF=14}
C {xschem_lib/inv.sym} -1200 1660 0 0 {name=X_inv126 NF=14}
C {lab_wire.sym} -1220 1580 0 0 {name=l2609 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 1660 0 0 {name=l2610 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1370 1620 0 0 {name=l2611 sig_type=std_logic lab=Di<25>}
C {lab_wire.sym} -1040 1620 0 0 {name=l2612 sig_type=std_logic lab=Di[25]}
C {xschem_lib/inv.sym} -960 1660 0 0 {name=X_inv127 NF=14}
C {xschem_lib/inv.sym} -800 1660 0 0 {name=X_inv128 NF=14}
C {lab_wire.sym} -820 1580 0 0 {name=l2613 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -820 1660 0 0 {name=l2614 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -970 1620 0 0 {name=l2615 sig_type=std_logic lab=Di<26>}
C {lab_wire.sym} -640 1620 0 0 {name=l2616 sig_type=std_logic lab=Di[26]}
C {xschem_lib/inv.sym} -560 1660 0 0 {name=X_inv129 NF=14}
C {xschem_lib/inv.sym} -400 1660 0 0 {name=X_inv130 NF=14}
C {lab_wire.sym} -420 1580 0 0 {name=l2617 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -420 1660 0 0 {name=l2618 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -570 1620 0 0 {name=l2619 sig_type=std_logic lab=Di<27>}
C {lab_wire.sym} -240 1620 0 0 {name=l2620 sig_type=std_logic lab=Di[27]}
C {xschem_lib/inv.sym} -1760 1790 0 0 {name=X_inv131 NF=14}
C {xschem_lib/inv.sym} -1600 1790 0 0 {name=X_inv132 NF=14}
C {lab_wire.sym} -1620 1710 0 0 {name=l2621 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1620 1790 0 0 {name=l2622 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1770 1750 0 0 {name=l2623 sig_type=std_logic lab=Di<28>}
C {lab_wire.sym} -1440 1750 0 0 {name=l2624 sig_type=std_logic lab=Di[28]}
C {xschem_lib/inv.sym} -1360 1790 0 0 {name=X_inv133 NF=14}
C {xschem_lib/inv.sym} -1200 1790 0 0 {name=X_inv134 NF=14}
C {lab_wire.sym} -1220 1710 0 0 {name=l2625 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 1790 0 0 {name=l2626 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1370 1750 0 0 {name=l2627 sig_type=std_logic lab=Di<29>}
C {lab_wire.sym} -1040 1750 0 0 {name=l2628 sig_type=std_logic lab=Di[29]}
C {xschem_lib/inv.sym} -960 1790 0 0 {name=X_inv135 NF=14}
C {xschem_lib/inv.sym} -800 1790 0 0 {name=X_inv136 NF=14}
C {lab_wire.sym} -820 1710 0 0 {name=l2629 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -820 1790 0 0 {name=l2630 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -970 1750 0 0 {name=l2631 sig_type=std_logic lab=Di<30>}
C {lab_wire.sym} -640 1750 0 0 {name=l2632 sig_type=std_logic lab=Di[30]}
C {xschem_lib/inv.sym} -560 1790 0 0 {name=X_inv137 NF=14}
C {xschem_lib/inv.sym} -400 1790 0 0 {name=X_inv138 NF=14}
C {lab_wire.sym} -420 1710 0 0 {name=l2633 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -420 1790 0 0 {name=l2634 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -570 1750 0 0 {name=l2635 sig_type=std_logic lab=Di<31>}
C {lab_wire.sym} -240 1750 0 0 {name=l2636 sig_type=std_logic lab=Di[31]}
C {devices/ipin.sym} -740 -2580 0 0 {name=p7 lab=Di<0>}
C {devices/opin.sym} -820 -2270 0 0 {name=p39 lab=Do[0]}
C {devices/ipin.sym} -650 -2580 0 0 {name=p8 lab=Di<1>}
C {devices/opin.sym} -730 -2270 0 0 {name=p40 lab=Do[1]}
C {devices/ipin.sym} -560 -2580 0 0 {name=p9 lab=Di<2>}
C {devices/opin.sym} -640 -2270 0 0 {name=p41 lab=Do[2]}
C {devices/ipin.sym} -470 -2580 0 0 {name=p10 lab=Di<3>}
C {devices/opin.sym} -550 -2270 0 0 {name=p42 lab=Do[3]}
C {devices/ipin.sym} -740 -2550 0 0 {name=p11 lab=Di<4>}
C {devices/opin.sym} -820 -2240 0 0 {name=p43 lab=Do[4]}
C {devices/ipin.sym} -650 -2550 0 0 {name=p12 lab=Di<5>}
C {devices/opin.sym} -730 -2240 0 0 {name=p44 lab=Do[5]}
C {devices/ipin.sym} -560 -2550 0 0 {name=p13 lab=Di<6>}
C {devices/opin.sym} -640 -2240 0 0 {name=p45 lab=Do[6]}
C {devices/ipin.sym} -470 -2550 0 0 {name=p14 lab=Di<7>}
C {devices/opin.sym} -550 -2240 0 0 {name=p46 lab=Do[7]}
C {devices/ipin.sym} -740 -2520 0 0 {name=p15 lab=Di<8>}
C {devices/opin.sym} -820 -2210 0 0 {name=p47 lab=Do[8]}
C {devices/ipin.sym} -650 -2520 0 0 {name=p16 lab=Di<9>}
C {devices/opin.sym} -730 -2210 0 0 {name=p48 lab=Do[9]}
C {devices/ipin.sym} -560 -2520 0 0 {name=p17 lab=Di<10>}
C {devices/opin.sym} -640 -2210 0 0 {name=p49 lab=Do[10]}
C {devices/ipin.sym} -470 -2520 0 0 {name=p18 lab=Di<11>}
C {devices/opin.sym} -550 -2210 0 0 {name=p50 lab=Do[11]}
C {devices/ipin.sym} -740 -2490 0 0 {name=p19 lab=Di<12>}
C {devices/opin.sym} -820 -2180 0 0 {name=p51 lab=Do[12]}
C {devices/ipin.sym} -650 -2490 0 0 {name=p20 lab=Di<13>}
C {devices/opin.sym} -730 -2180 0 0 {name=p52 lab=Do[13]}
C {devices/ipin.sym} -560 -2490 0 0 {name=p21 lab=Di<14>}
C {devices/opin.sym} -640 -2180 0 0 {name=p53 lab=Do[14]}
C {devices/ipin.sym} -470 -2490 0 0 {name=p22 lab=Di<15>}
C {devices/opin.sym} -550 -2180 0 0 {name=p54 lab=Do[15]}
C {devices/ipin.sym} -740 -2460 0 0 {name=p23 lab=Di<16>}
C {devices/opin.sym} -820 -2150 0 0 {name=p55 lab=Do[16]}
C {devices/ipin.sym} -650 -2460 0 0 {name=p24 lab=Di<17>}
C {devices/opin.sym} -730 -2150 0 0 {name=p56 lab=Do[17]}
C {devices/ipin.sym} -560 -2460 0 0 {name=p25 lab=Di<18>}
C {devices/opin.sym} -640 -2150 0 0 {name=p57 lab=Do[18]}
C {devices/ipin.sym} -470 -2460 0 0 {name=p26 lab=Di<19>}
C {devices/opin.sym} -550 -2150 0 0 {name=p58 lab=Do[19]}
C {devices/ipin.sym} -740 -2430 0 0 {name=p27 lab=Di<20>}
C {devices/opin.sym} -820 -2120 0 0 {name=p59 lab=Do[20]}
C {devices/ipin.sym} -650 -2430 0 0 {name=p28 lab=Di<21>}
C {devices/opin.sym} -730 -2120 0 0 {name=p60 lab=Do[21]}
C {devices/ipin.sym} -560 -2430 0 0 {name=p29 lab=Di<22>}
C {devices/opin.sym} -640 -2120 0 0 {name=p61 lab=Do[22]}
C {devices/ipin.sym} -470 -2430 0 0 {name=p30 lab=Di<23>}
C {devices/opin.sym} -550 -2120 0 0 {name=p62 lab=Do[23]}
C {devices/ipin.sym} -740 -2400 0 0 {name=p31 lab=Di<24>}
C {devices/opin.sym} -820 -2090 0 0 {name=p63 lab=Do[24]}
C {devices/ipin.sym} -650 -2400 0 0 {name=p32 lab=Di<25>}
C {devices/opin.sym} -730 -2090 0 0 {name=p64 lab=Do[25]}
C {devices/ipin.sym} -560 -2400 0 0 {name=p33 lab=Di<26>}
C {devices/opin.sym} -640 -2090 0 0 {name=p65 lab=Do[26]}
C {devices/ipin.sym} -470 -2400 0 0 {name=p34 lab=Di<27>}
C {devices/opin.sym} -550 -2090 0 0 {name=p66 lab=Do[27]}
C {devices/ipin.sym} -740 -2370 0 0 {name=p35 lab=Di<28>}
C {devices/opin.sym} -820 -2060 0 0 {name=p67 lab=Do[28]}
C {devices/ipin.sym} -650 -2370 0 0 {name=p36 lab=Di<29>}
C {devices/opin.sym} -730 -2060 0 0 {name=p68 lab=Do[29]}
C {devices/ipin.sym} -560 -2370 0 0 {name=p37 lab=Di<30>}
C {devices/opin.sym} -640 -2060 0 0 {name=p69 lab=Do[30]}
C {devices/ipin.sym} -470 -2370 0 0 {name=p38 lab=Di<31>}
C {devices/opin.sym} -550 -2060 0 0 {name=p70 lab=Do[31]}
C {iopin.sym} -340 -2580 0 0 {name=p71 lab=VDD}
C {iopin.sym} -340 -2550 0 0 {name=p72 lab=VSS}
C {ipin.sym} -290 -2500 0 0 {name=p73 lab=WE0}
C {ipin.sym} -290 -2470 0 0 {name=p74 lab=WE1}
C {ipin.sym} -290 -2440 0 0 {name=p75 lab=WE2}
C {ipin.sym} -290 -2410 0 0 {name=p76 lab=WE3}
C {ipin.sym} -290 -2370 0 0 {name=p77 lab=CLK}
C {lab_wire.sym} -1550 -2040 0 0 {name=l2637 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1550 -1940 2 0 {name=l2638 sig_type=std_logic lab=VSS}
C {xschem_lib/inv.sym} -1440 -1950 0 0 {name=X_inv139 NF=32}
C {xschem_lib/inv.sym} -1280 -1950 0 0 {name=X_inv140 NF=64}
C {lab_wire.sym} -1380 -2040 0 0 {name=l2639 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1380 -1940 2 0 {name=l2640 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1220 -2040 0 0 {name=l2641 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1220 -1940 2 0 {name=l2642 sig_type=std_logic lab=VSS}
C {xschem_lib/inv.sym} -2100 -1950 0 0 {name=X_inv143 NF=2}
C {xschem_lib/inv.sym} -1940 -1950 0 0 {name=X_inv144 NF=4}
C {lab_wire.sym} -2040 -2040 0 0 {name=l2647 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2040 -1940 2 0 {name=l2648 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1880 -2040 0 0 {name=l2649 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1880 -1940 2 0 {name=l2650 sig_type=std_logic lab=VSS}
